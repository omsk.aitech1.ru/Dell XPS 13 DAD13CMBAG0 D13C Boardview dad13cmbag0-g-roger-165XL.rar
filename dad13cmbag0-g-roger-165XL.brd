# Allegro board dad13cmbag0-g-roger-165XL.brd (continued)
## Nets (continued)
GND: C1.2 C2.2 C3.2 C4.2 C5.2 C6.2 C8.2 C9.2 C11.2 C12.2 C14.2 C15.2 C17.2 C18.1 C19.2 C21.2 C22.2 C23.2 C24.2 C25.2 C26.2 C27.2 C28.2 C29.2 C30.2 C31.2 C32.2 C33.2 C34.2 C35.2 C36.2 C37.2 C38.2 C39.2 C40.2 C41.1 C42.2 C44.2 C46.2 C47.2 C48.2 C49.2 C50.2 C51.2 C52.2 C53.2 C54.2 C57.2 C58.1 C59.2 C60.1 C61.2 C62.2 C63.2 C64.1 C65.2 C66.2 C67.2 C68.2 C69.2 C70.2 C71.2 C72.2 C73.1 C75.2 C76.2 C77.2 C78.2 C79.2 C80.2 C81.2 C82.2 C84.2 C85.1 C86.1 C87.2 C88.2 C90.2 C91.2 C92.2 C93.2 C94.1 C95.2 C96.2 C97.1 C98.2 C99.2 C100.1 C101.2 C103.1 C104.2 C105.1 C106.2 C107.1 C108.2 C109.2 C110.2 C112.2 C113.2 C114.2 C115.2 C116.2 C117.2 C118.2 C119.1 C120.1 C121.1 C122.1 C123.1 C124.2 C125.1 C126.2 C127.2 C128.2 C129.1 C130.1 C131.1 C133.2 C134.2 C135.2 C136.2 C137.2 C138.2 C140.2 C141.2 C142.2 C143.2 C145.2 C147.2 C149.2 C151.2 C152.2 C153.2 C156.2 C158.2 C159.2 C160.2 C161.2 C162.2 C163.2 C164.2 C165.2 C166.2 C167.2 C170.2 C171.2 C172.2 C173.2 C174.2 C175.2 C176.2 C177.2 C178.2 C179.2 C180.2 C181.2 C182.2 C183.2 C184.2 C185.2 C186.2 C187.2 C188.2 C189.2 C190.2 C191.2 C192.2 C193.2 C194.2 C195.2 C197.2 C198.2 C199.2 C200.2 C201.2 C202.2 C203.2 C204.2 C205.2 C206.2 C207.2 C208.2 C209.2 C210.2 C211.2 C212.2 C213.2 C214.2 C215.2 C216.2 C217.2 C218.2 C219.2 C220.2 C221.2 C222.2 C223.2 C224.2 C225.2 C226.2 C227.2 C228.2 C229.2 C230.2 C231.2 C232.2 C233.2 C234.2 C235.2 C236.2 C237.2 C238.2 C239.2 C242.2 C245.2 C246.1 C247.2 C254.2 C257.2 C258.2 C259.2 C260.2 C261.1 C262.2 C263.2 C264.2 C265.2 C266.2 C267.1 C268.2 C269.2 C273.2 C274.2 C275.2 C276.2 C277.2 C278.2 C279.2 C280.2 C281.2 C282.2 C283.2 C284.2 C285.2 C286.2 C287.2 C288.2 C289.2 C290.2 C291.2 C292.2 C293.2 C294.2 C295.2 C296.2 C297.2 C298.2 C299.2 C300.2 C301.2 C302.2 C303.2 C304.2 C305.2 C306.2 C307.2 C308.2 C309.2 C310.2 C311.2 C312.2 C313.2 C526.2 C527.2 CN1.1 CN1.7 CN1.8 CN1.13 CN1.14 CN1.19 CN1.21 CN1.22 CN1.23 CN1.24 CN1.25 CN1.26 CN2.4 CN2.7 CN2.11 CN2.12 CN2.13 CN2.14 CN3.12 CN3.23 CN3.28 CN3.31 CN3.34 CN3.37 CN3.38 CN3.41 CN3.42 CN3.45 CN3.55 CN3.56 CN4.1 CN4.7 CN4.18 CN4.33 CN4.39 CN4.45 CN4.51 CN4.57 CN4.63 CN4.69 CN4.75 CN4.76 CN4.77 CN5.3 CN5.4 CN6.6 CN6.7 CN6.8 CN7.1 CN7.2 CN7.6 CN7.7 CON1.4 CON1.9 CON1.15 CON1.18 CON1.21 CON1.26 CON1.27 CON1.29 CON1.34 CON1.35 CON1.37 CON1.40 CON1.50 CON1.53 CON1.54 EC1.2 EC2.1 EC3.2 EC4.2 EC5.2 EC6.2 EC7.2 EC8.2 EC9.2 EC10.2 EC11.2 EC12.2 EC13.2 EC14.2 EC15.2 EC16.2 EC17.2 EC18.2 EC19.2 EC20.2 EC21.2 EC22.2 EC23.2 EC24.2 EC25.2 EC26.2 EC27.2 EC28.2 EC29.2 EC30.2 EC31.2 EC32.2 EC33.2 EC34.2 EC35.2 EC36.2 EC37.2 EC38.2 EC39.2 EC40.2 EC41.2 EC42.2 EC43.2 EC44.2 EC45.2 EC46.2 EC47.2 EC48.2 EC49.2 EC50.2 EC51.2 EC52.2 EC53.2 EC54.2 EC55.2 EC56.2 EC57.2 EC58.2 EC59.2 EC60.2 EC61.1 EC62.2 EC63.2 EC64.2 EC65.2 EC66.2 EC68.2 EC69.2 EC70.2 EC71.2 EC72.2 EC73.2 EC74.2 EC75.2 EC76.2 EC77.2 EC78.2 EC79.2 EC80.2 ESD1.2 ESD2.2 ESD3.2 EU1.3 EU1.8 H1.1 H3.1 H4.1 H5.1 H6.1 H7.1 H8.1 H9.1 H10.1 H12.1 H13.1 H14.1 J1.18 J1.23 J1.26 J1.29 J1.32 J1.35 J1.38 J1.41 J1.42 J1.43 J1.44 J2.5 J2.6 JBAT1.1 JBAT1.2 JBAT1.B1 JBAT1.B2 JBAT1.B4 JKB1.30 JKB1.31 JKB1.32 JP1.4 JP1.9 JP1.10 JP2.7 JP2.9 JP2.10 L1.2 PC6.2 PC7.2 PC8.2 PC9.2 PC10.2 PC11.2 PC12.2 PC13.2 PC14.2 PC15.2 PC16.2 PC17.2 PC18.2 PC19.2 PC20.2 PC21.2 PC22.2 PC23.2 PC24.2 PC25.2 PC26.2 PC27.2 PC28.2 PC29.2 PC30.2 PC31.2 PC32.2 PC33.2 PC34.2 PC35.2 PC36.2 PC37.2 PC38.2 PC39.2 PC40.2 PC42.2 PC43.2 PC44.2 PC45.2 PC46.2 PC47.2 PC48.1 PC49.2 PC50.2 PC51.2 PC52.2 PC53.2 PC54.2 PC55.2 PC56.2 PC60.2 PC61.2 PC62.2 PC63.2 PC64.2 PC65.2 PC70.1 PC71.2 PC72.2 PC73.1 PC74.2 PC75.2 PC76.1 PC77.2 PC78.2 PC79.2 PC80.2 PC84.2 PC88.2 PC89.2 PC91.2 PC94.2 PC96.1 PC98.2 PC99.2 PC100.2 PC102.2 PC103.2 PC104.2 PC105.2 PC106.2 PC107.2 PC108.2 PC109.2 PC111.2 PC112.2 PC113.2 PC114.2 PC115.2 PC116.2 PC117.2 PC118.2 PC119.2 PC120.2 PC121.2 PC124.2 PC125.2 PC126.1 PC127.1 PC128.1 PC129.2 PC130.2 PC131.2 PC132.2 PC133.2 PC134.2 PC135.2 PC136.2 PC137.2 PC138.2 PC139.2 PC140.2 PC142.2 PC144.2 PC146.2 PC148.2 PC149.2 PC152.2 PC156.2 PC159.2 PC160.2 PC161.2 PC163.2 PC164.2 PC165.2 PC166.2 PC167.2 PC168.2 PC169.2 PC171.2 PC172.2 PC173.2 PC174.2 PC175.2 PC176.2 PC177.2 PC178.2 PC179.2 PC180.2 PC181.2 PC182.2 PC183.2 PC184.2 PC185.2 PC186.2 PC187.2 PC188.2 PC189.2 PC190.2 PC191.2 PC192.2 PC193.2 PC194.2 PC195.2 PC196.2 PC197.2 PC198.2 PC199.2 PC200.2 PC201.2 PC202.2 PC203.2 PC204.2 PC205.2 PC206.2 PC207.2 PC208.2 PC209.2 PC211.2 PC212.2 PC213.2 PC214.2 PC215.2 PC216.2 PC217.2 PC218.2 PC219.2 PD6.2 PQ1.1 PQ1.4 PQ2.1 PQ2.4 PQ3.1 PQ6.1 PQ6.4 PQ7.1 PQ7.4 PQ8.1 PQ11.1 PQ12.1 PQ13.1 PQ14.1 PQ14.4 PQ18.1 PQ19.3 PQ19.9 PQ20.1 PQ20.2 PQ20.3 PQ23.1 PQ23.2 PQ23.3 PQ24.1 PQ24.2 PQ24.3 PQ29.1 PQ29.2 PQ29.3 PQ31.1 PQ32.1 PR8.2 PR41.2 PR42.2 PR45.2 PR49.2 PR58.2 PR61.2 PR62.2 PR63.2 PR68.2 PR69.2 PR77.2 PR80.2 PR81.2 PR90.1 PR93.2 PR95.2 PR96.2 PR98.2 PR106.2 PR108.2 PR109.2 PR111.2 PR112.2 PR114.2 PR118.2 PR123.2 PR125.2 PR130.2 PR132.2 PR135.2 PR144.2 PR145.2 PR147.2 PR156.2 PR157.2 PR196.2 PR199.2 PR207.2 PR214.2 PR220.2 PR231.2 PU1.17 PU1.18 PU1.25 PU2.11 PU2.15 PU3.11 PU3.15 PU4.5 PU4.9 PU5.11 PU5.15 PU6.2 PU7.21 PU8.4 PU9.11 PU9.15 PU10.1 PU10.3 PU10.14 PU10.21 PU11.2 PU12.14 PU13.11 PU13.15 PU14.11 PU14.15 PU15.11 PU15.15 PU16.11 PU16.15 PU17.10 PU17.11 PU17.12 PU17.13 PU17.14 PU17.19 PU17.20 PU17.24 PU17.25 PU17.29 PU18.29 PU18.33 PU18.34 PU18.35 PU18.36 PU18.37 PU18.38 PU18.39 PU18.40 PU18.41 PU18.42 PU19.5 PU19.9 PU20.2 PU21.11 Q2.1 Q3.1 Q4.1 Q4.4 Q5.1 Q8.1 Q14.1 Q20.1 Q21.1 Q22.1 Q23.1 Q31.1 Q33.1 Q34.1 Q35.1 Q37.1 Q38.1 Q39.1 Q40.1 Q41.1 Q42.1 Q42.4 Q43.1 Q43.4 Q44.1 Q44.4 R2.1 R4.2 R7.2 R8.1 R10.2 R11.2 R14.2 R16.2 R17.2 R18.2 R19.2 R31.2 R33.2 R34.2 R36.2 R43.2 R46.2 R57.2 R66.2 R71.2 R74.2 R83.2 R88.2 R96.2 R97.2 R101.2 R102.2 R104.1 R105.1 R109.2 R112.1 R117.2 R120.2 R121.2 R126.2 R140.2 R142.2 R148.2 R149.1 R150.1 R151.1 R155.1 R157.2 R161.2 R163.2 R166.2 R191.2 R207.2 R232.1 R237.2 R242.2 R248.2 R249.2 R250.2 R251.2 R252.2 R255.1 R259.2 R268.2 R271.2 R274.2 R275.2 R287.2 R296.2 R298.1 R300.2 R301.2 R306.2 R310.2 R329.2 R330.2 R343.2 R346.2 R351.2 R352.2 R353.2 R354.2 R355.2 R360.2 R363.2 R371.2 R375.2 R377.2 R380.2 R381.2 R382.2 R383.2 R384.2 R387.2 R392.2 R393.2 R394.2 R396.2 R397.2 R398.2 R399.2 R400.2 R401.2 R402.2 R403.2 R460.2 R461.2 RP25.2 RP25.4 RP25.6 RP25.8 RTCBT1.1 RTCR2.2 SJ1.1 SJ5.2 SW1.2 U1.3 U2.4 U3.4 U4.E5 U4.F4 U4.F5 U4.G4 U4.G5 U4.H5 U5.2 U6.1 U6.2 U6.3 U6.4 U6.8 U6.9 U6.11 U6.18 U6.25 U7.14 U7.17 U8.6 U9.3 U10.44 U10.49 U11.6 U12.3 U13.6 U14.3 U15.4 U16.A11 U16.A14 U16.A18 U16.A24 U16.A28 U16.A32 U16.A36 U16.A40 U16.A44 U16.A48 U16.A52 U16.A56 U16.AA1 U16.AA58 U16.AB7 U16.AB10 U16.AB20 U16.AB22 U16.AC61 U16.AD3 U16.AD21 U16.AD63 U16.AE5 U16.AE10 U16.AE58 U16.AF11 U16.AF12 U16.AF14 U16.AF15 U16.AF17 U16.AF18 U16.AG1 U16.AG11 U16.AG21 U16.AG23 U16.AG60 U16.AG61 U16.AG62 U16.AG63 U16.AH16 U16.AH17 U16.AH19 U16.AH20 U16.AH22 U16.AH24 U16.AH28 U16.AH30 U16.AH32 U16.AH34 U16.AH36 U16.AH38 U16.AH40 U16.AH42 U16.AH44 U16.AH46 U16.AH49 U16.AH51 U16.AH53 U16.AH55 U16.AH57 U16.AJ13 U16.AJ14 U16.AJ23 U16.AJ25 U16.AJ27 U16.AJ29 U16.AJ35 U16.AJ39 U16.AJ41 U16.AJ43 U16.AJ45 U16.AJ47 U16.AJ50 U16.AJ52 U16.AJ54 U16.AJ56 U16.AJ58 U16.AJ60 U16.AJ63 U16.AK3 U16.AK23 U16.AK52 U16.AL10 U16.AL13 U16.AL17 U16.AL20 U16.AL22 U16.AL23 U16.AL26 U16.AL29 U16.AL31 U16.AL33 U16.AL36 U16.AL39 U16.AL40 U16.AL45 U16.AL46 U16.AL51 U16.AL52 U16.AL54 U16.AL57 U16.AL60 U16.AL61 U16.AM1 U16.AM17 U16.AM23 U16.AM31 U16.AM52 U16.AN7 U16.AN17 U16.AN23 U16.AN31 U16.AN32 U16.AN35 U16.AN36 U16.AN39 U16.AN40 U16.AN42 U16.AN43 U16.AN45 U16.AN46 U16.AN48 U16.AN49 U16.AN51 U16.AN52 U16.AN60 U16.AN63 U16.AP3 U16.AP10 U16.AP17 U16.AP20 U16.AP22 U16.AP23 U16.AP26 U16.AP29 U16.AP31 U16.AP38 U16.AP39 U16.AP48 U16.AP52 U16.AP54 U16.AP57 U16.AR5 U16.AR11 U16.AR15 U16.AR17 U16.AR23 U16.AR31 U16.AR33 U16.AR39 U16.AR43 U16.AR49 U16.AR52 U16.AT13 U16.AT35 U16.AT37 U16.AT40 U16.AT42 U16.AT43 U16.AT46 U16.AT49 U16.AT61 U16.AT62 U16.AT63 U16.AU1 U16.AU16 U16.AU18 U16.AU20 U16.AU22 U16.AU24 U16.AU26 U16.AU28 U16.AU30 U16.AU33 U16.AU51 U16.AU53 U16.AU55 U16.AU57 U16.AU59 U16.AV8 U16.AV14 U16.AV16 U16.AV20 U16.AV24 U16.AV28 U16.AV33 U16.AV34 U16.AV36 U16.AV39 U16.AV41 U16.AV43 U16.AV46 U16.AV49 U16.AV51 U16.AV55 U16.AV59 U16.AW4 U16.AW16 U16.AW24 U16.AW33 U16.AW35 U16.AW37 U16.AW40 U16.AW42 U16.AW44 U16.AW47 U16.AW50 U16.AW51 U16.AW59 U16.AW60 U16.AY4 U16.AY6 U16.AY11 U16.AY16 U16.AY18 U16.AY22 U16.AY24 U16.AY26 U16.AY30 U16.AY33 U16.AY51 U16.AY53 U16.AY57 U16.AY59 U16.B4 U16.B20 U16.B24 U16.B26 U16.B28 U16.B32 U16.B36 U16.B40 U16.B44 U16.B48 U16.B52 U16.B56 U16.B60 U16.C11 U16.C14 U16.C18 U16.C20 U16.C25 U16.C27 U16.C38 U16.C39 U16.C57 U16.D2 U16.D5 U16.D8 U16.D12 U16.D14 U16.D18 U16.D21 U16.D23 U16.D25 U16.D26 U16.D27 U16.D29 U16.D30 U16.D31 U16.D33 U16.D34 U16.D35 U16.D37 U16.D38 U16.D39 U16.D41 U16.D42 U16.D43 U16.D45 U16.D46 U16.D47 U16.D49 U16.D50 U16.D51 U16.D53 U16.D54 U16.D55 U16.D57 U16.D59 U16.D62 U16.D63 U16.E11 U16.E17 U16.F20 U16.F26 U16.F30 U16.F34 U16.F38 U16.F42 U16.F46 U16.F50 U16.F54 U16.F58 U16.F61 U16.G3 U16.G5 U16.G6 U16.G8 U16.G18 U16.G22 U16.H13 U16.H17 U16.H57 U16.J10 U16.J22 U16.J59 U16.J63 U16.K1 U16.K12 U16.L7 U16.L13 U16.L15 U16.L17 U16.L18 U16.L20 U16.L58 U16.L61 U16.M22 U16.N3 U16.N10 U16.N21 U16.P22 U16.P59 U16.P62 U16.P63 U16.R8 U16.R10 U16.R22 U16.T1 U16.T58 U16.U9 U16.U20 U16.U22 U16.U61 U16.V3 U16.V7 U16.V10 U16.V23 U16.V58 U16.W20 U16.W22 U16.Y10 U16.Y59 U16.Y63 U17.3 U18.A9 U18.B1 U18.B3 U18.B9 U18.D1 U18.D3 U18.D8 U18.E1 U18.E2 U18.E7 U18.E8 U18.F9 U18.G1 U18.G8 U18.G9 U18.J2 U18.J8 U18.M1 U18.M9 U18.P1 U18.P9 U18.T1 U18.T9 U19.A9 U19.B1 U19.B3 U19.B9 U19.D1 U19.D3 U19.D8 U19.E1 U19.E2 U19.E7 U19.E8 U19.F9 U19.G1 U19.G8 U19.G9 U19.J2 U19.J8 U19.M1 U19.M9 U19.P1 U19.P9 U19.T1 U19.T9 U20.A9 U20.B1 U20.B3 U20.B9 U20.D1 U20.D3 U20.D8 U20.E1 U20.E2 U20.E7 U20.E8 U20.F9 U20.G1 U20.G8 U20.G9 U20.J2 U20.J8 U20.M1 U20.M9 U20.P1 U20.P9 U20.T1 U20.T9 U21.A9 U21.B1 U21.B3 U21.B9 U21.D1 U21.D3 U21.D8 U21.E1 U21.E2 U21.E7 U21.E8 U21.F9 U21.G1 U21.G8 U21.G9 U21.J2 U21.J8 U21.M1 U21.M9 U21.P1 U21.P9 U21.T1 U21.T9 U22.A9 U22.B1 U22.B3 U22.B9 U22.D1 U22.D3 U22.D8 U22.E1 U22.E2 U22.E7 U22.E8 U22.F9 U22.G1 U22.G8 U22.G9 U22.J2 U22.J8 U22.M1 U22.M9 U22.P1 U22.P9 U22.T1 U22.T9 U23.A9 U23.B1 U23.B3 U23.B9 U23.D1 U23.D3 U23.D8 U23.E1 U23.E2 U23.E7 U23.E8 U23.F9 U23.G1 U23.G8 U23.G9 U23.J2 U23.J8 U23.M1 U23.M9 U23.P1 U23.P9 U23.T1 U23.T9 U24.A9 U24.B1 U24.B3 U24.B9 U24.D1 U24.D3 U24.D8 U24.E1 U24.E2 U24.E7 U24.E8 U24.F9 U24.G1 U24.G8 U24.G9 U24.J2 U24.J8 U24.M1 U24.M9 U24.P1 U24.P9 U24.T1 U24.T9 U25.A9 U25.B1 U25.B3 U25.B9 U25.D1 U25.D3 U25.D8 U25.E1 U25.E2 U25.E7 U25.E8 U25.F9 U25.G1 U25.G8 U25.G9 U25.J2 U25.J8 U25.M1 U25.M9 U25.P1 U25.P9 U25.T1 U25.T9 Y1.2 Y1.4 Y2.2 Y2.4
VCCAPLLOPI_VAL: TP13.1 U16.Y20
VCCSENSE: PR167.1 R32.1 U16.E63
VCCST_PWRGD#: Q23.2 Q37.2 U4.A4
VCCST_PWRGD_L: Q23.3 R261.2 U16.B59
VSSSENSE: PR166.1 R33.1 U16.E62
1P05V_EN: PR174.2 PR175.2 PU17.28
1P05V_GSNS: PR157.1 PU17.23
1P05V_VREF: PC156.1 PU17.26
1P05V_VSNS: PR158.1 PU17.22
1P35V_BOOT: PR104.1 PU10.18
1P35V_CS: PR90.2 PU10.13
1P35V_FB: PC41.2 PR71.2 PR77.1 PU10.6
1P35V_LGATE: PQ24.4 PU10.15 TP40.1
1P35V_PHASE: PC81.2 PC101.1 PL4.2 PQ24.5 PQ24.6 PQ24.7 PQ24.8 PQ25.1 PQ25.2 PQ25.3 PU10.16
1P35V_S3: PC48.2 PR50.2 PR55.2 PU10.7
1P35V_S5: PR66.2 PR75.2 PU10.8
1P35V_TON: PR73.1 PU10.9
1P35V_UGATE: PQ25.4 PU10.17 TP43.1
1P35V_VDD: PC64.1 PR82.1 PU10.12
1P35V_VDDQ: PR228.2 PU10.5
1P35V_VID: PR83.2 PU10.11
1P35V_VLDOIN: PC80.1 PR202.2 PU10.19
8230_BOOT1: PR79.1 PU7.19
8230_BOOT2: PR78.1 PU7.7
8230_BYP1: PC47.1 PU7.20 SJ4.2
8230_FB1: PR54.2 PR62.1 PU7.1
8230_FB1_P: PR54.1 SJ3.2
8230_FB2: PR53.2 PR61.1 PU7.5
8230_FB2_P: PR53.1 SJ2.2
8230_LGAT2: PC66.1 PC67.1 PQ20.4 PU7.10 TP38.1
8230_LGATE1: PQ23.4 PU7.16 TP137.1
8230_PHASE1: PC59.2 PC93.1 PL5.1 PQ22.1 PQ22.2 PQ22.3 PQ23.5 PQ23.6 PQ23.7 PQ23.8 PU7.17
8230_PHASE2: PC58.2 PC92.1 PL6.2 PQ20.5 PQ20.6 PQ20.7 PQ20.8 PQ21.1 PQ21.2 PQ21.3 PU7.9
8230_UGATE1: PQ22.4 PU7.18 TP39.1
8230_UGATE2: PQ21.4 PU7.8 TP41.1
8230_VIN: PC73.2 PR92.2 PU7.11 PU7.12
51622_ALERT#: PR183.1 PU18.32
51622_B-RAMP: PR22.1 PR177.2 PU18.11
51622_COMP: PC151.1 PR155.1 PR160.1 PR170.2 PU18.26
51622_CSN1: PC145.2 PC150.2 PL3.4 PR193.2 PR194.1 PU18.18
51622_CSP1: PC145.1 PC150.1 PR184.1 PR192.2 PR193.1 PU18.17
51622_DROOP: PC143.2 PC151.2 PR160.2 PU18.25
51622_F-IMAX: PR25.1 PR178.2 PU18.10
51622_GFB: PR166.2 PU18.23
51622_IMON: PC154.1 PR21.1 PU18.13
51622_O-USR: PR180.2 PR182.1 PU18.9
51622_OCP-I: PR20.1 PR21.2 PU18.12
51622_PWM1: PQ19.8 PU18.6
51622_SKIP#: PR186.1 PU18.7
51622_THERM: PC153.1 PR169.1 PR172.2 PU18.14
51622_V5A: PC160.1 PR19.1 PU18.28
51622_VCLK: PR24.2 PR181.1 PU18.31
51622_VDIO: PR189.1 PR190.2 PU18.1
51622_VDO: PC162.1 PR27.1 PU18.2
51622_VFB: PR167.2 PU18.24
51622_VR_HOT: PR179.1 PU18.30
51622_VR_ON: PR185.1 PU18.8
51622_VREF: PC155.1 PR17.2 PR170.1 PR172.1 PR177.1 PR178.1 PR180.1 PU18.27
+5P0V_PROCHOT: PD1.5 PQ31.3
+DC_IN: EC12.1 FL2.2 PC200.1 PR124.1 PR131.1 PV1.1
+DC_IN_S: PD4.2 PQ27.5 PQ27.6 PQ27.7 PQ27.8 PR89.1 PV2.1
+DC_IN_SS: EC13.1 EC14.1 PC110.1 PQ26.1 PQ26.2 PQ26.3 PQ27.1 PQ27.2 PQ27.3 PR105.1 PR150.1 PR231.1
+DCIN_JACK: CN7.4 CN7.5 EC16.1 EC21.1 EC27.1 EC80.1 FL2.1 PC203.1 PC204.1 PC207.1
+DCPSUSBYP: C113.1 C525.2 U16.AG19 U16.AG20
+DDR_VTTREF: PC63.1 PU10.4
+DSP_VREF_IN: C157.2 C158.1 PR103.2 PR106.1 U10.40
+DVDIO: R146.1 R463.1 U10.9
+KB_LED_PWR: FS1.2 J2.4
+LCDVCC: C67.1 C72.1 J1.4 J1.5 R80.2
+LED_BL: C75.1 J1.1 J1.2 PC161.1 PC164.1 PD8.1 PR13.1
+LED_PWRSRC: PC131.1 PC146.1 PL2.1 PQ17.3 PU1.23
+PWR_SRC: EC5.1 EC7.1 EC8.1 EC9.1 EC50.1 EC51.1 EC52.1 EC53.1 EC69.1 EC70.1 EC71.1 EC72.1 EC73.1 EC74.1 EC75.1 EC76.1 EC77.1 EC78.1 EC79.1 PC132.1 PC133.1 PC134.1 PC135.1 PC141.1 PC148.1 PC149.1 PC159.1 PC165.1 PC182.1 PC183.1 PC184.1 PC185.1 PC187.1 PC188.1 PC194.1 PC195.1 PC212.1 PC213.1 PC219.1 PL7.2 PQ17.1 PQ19.5 PQ21.5 PQ21.6 PQ21.7 PQ21.8 PQ22.5 PQ22.6 PQ22.7 PQ22.8 PQ25.5 PQ25.6 PQ25.7 PQ25.8 PR73.2 PR92.1 PR152.1 PR165.1 PR204.1 PR211.1 PU17.15 PU17.16 PU17.17
+RTC_1: RTCBT1.2 RTCR4.2
+RTC_CELL: C69.1 C163.1 D18.3 R122.2 R179.2 R180.2 R361.1 R362.1 R365.1 U4.J4
+SMDDR_VREF_CA: C179.1 C181.1 C184.1 C185.1 C186.1 C187.1 C190.1 C191.1 R373.2 R377.1 R378.2 U18.M8 U19.M8 U20.M8 U21.M8 U22.M8 U23.M8 U24.M8 U25.M8
+SMDDR_VREF_DQA: C170.1 C172.1 C174.1 C175.1 R372.2 R375.1 R376.2 U18.H1 U19.H1 U20.H1 U21.H1
+SMDDR_VREF_DQB: C171.1 C173.1 C176.1 C177.1 R374.2 R379.2 R380.1 U22.H1 U23.H1 U24.H1 U25.H1
+USB0_SIDE_PWR: C88.1 C90.1 C93.1 C127.1 C260.1 CN2.1 U7.12
+V_VDDQ_VR: C114.1 C115.1 C116.1 C117.1 C118.1 C136.1 C196.1 C207.1 C208.1 C210.1 C211.1 C212.1 C213.1 C214.1 C215.1 C216.1 C217.1 C218.1 C219.1 C220.1 C221.1 C222.1 C223.1 C224.1 C225.1 C226.1 C227.1 C228.1 C229.1 C230.1 C231.1 C232.1 C233.1 C234.1 C235.1 C259.1 C263.1 C264.1 C265.1 C266.1 C269.1 C282.1 C283.1 C284.1 C285.1 C286.1 C287.1 C288.1 C289.1 C290.1 C291.1 C292.1 C293.1 C294.1 C295.1 C296.1 C297.1 C298.1 C299.1 C300.1 C301.1 C302.1 C303.1 C304.1 C305.1 C306.1 C307.1 C308.1 C309.1 C310.1 C311.1 C312.1 C313.1 PC190.1 PC193.1 PL4.1 PR202.1 PR227.1 PR228.1 PR229.2 Q19.1 R244.2 R245.1 R247.2 R356.2 R376.1 R378.1 R379.1 R410.1 U16.AH26 U16.AJ31 U16.AJ33 U16.AJ37 U16.AN33 U16.AP43 U16.AR48 U16.AY35 U16.AY40 U16.AY44 U16.AY50 U17.5 U18.A1 U18.A8 U18.B2 U18.C1 U18.C9 U18.D2 U18.D9 U18.E9 U18.F1 U18.G7 U18.H2 U18.H9 U18.K2 U18.K8 U18.N1 U18.N9 U18.R1 U18.R9 U19.A1 U19.A8 U19.B2 U19.C1 U19.C9 U19.D2 U19.D9 U19.E9 U19.F1 U19.G7 U19.H2 U19.H9 U19.K2 U19.K8 U19.N1 U19.N9 U19.R1 U19.R9 U20.A1 U20.A8 U20.B2 U20.C1 U20.C9 U20.D2 U20.D9 U20.E9 U20.F1 U20.G7 U20.H2 U20.H9 U20.K2 U20.K8 U20.N1 U20.N9 U20.R1 U20.R9 U21.A1 U21.A8 U21.B2 U21.C1 U21.C9 U21.D2 U21.D9 U21.E9 U21.F1 U21.G7 U21.H2 U21.H9 U21.K2 U21.K8 U21.N1 U21.N9 U21.R1 U21.R9 U22.A1 U22.A8 U22.B2 U22.C1 U22.C9 U22.D2 U22.D9 U22.E9 U22.F1 U22.G7 U22.H2 U22.H9 U22.K2 U22.K8 U22.N1 U22.N9 U22.R1 U22.R9 U23.A1 U23.A8 U23.B2 U23.C1 U23.C9 U23.D2 U23.D9 U23.E9 U23.F1 U23.G7 U23.H2 U23.H9 U23.K2 U23.K8 U23.N1 U23.N9 U23.R1 U23.R9 U24.A1 U24.A8 U24.B2 U24.C1 U24.C9 U24.D2 U24.D9 U24.E9 U24.F1 U24.G7 U24.H2 U24.H9 U24.K2 U24.K8 U24.N1 U24.N9 U24.R1 U24.R9 U25.A1 U25.A8 U25.B2 U25.C1 U25.C9 U25.D2 U25.D9 U25.E9 U25.F1 U25.G7 U25.H2 U25.H9 U25.K2 U25.K8 U25.N1 U25.N9 U25.R1 U25.R9
+VCHGR: JBAT1.B8 JBAT1.B9 PC126.2 PC127.2 PC128.2 PQ30.5 PQ30.6 PQ30.7 PQ30.8
+VCHGR_IN: EC15.1 EC17.1 PC196.1 PC202.1 PQ28.5 PQ28.6 PQ28.7 PQ28.8 PR210.2
AC_OFF: PQ10.2 R99.2
AC_PRESENT: R115.1 U4.A1 U16.AJ8
ACAV_IN: D12.1 PQ32.2 PR98.1 PR102.2 PU12.5 Q5.2
ACZ_SPKR: CN3.47 U16.V2
ALS_EN_R: PR112.1 PR113.1 PU14.3
ALS_INT: J1.21 U4.A9
ALS_PWR_EN: PR113.2 U16.AG3
ALW_ON: PQ7.5 Q4.2 U4.A12
APWROK: R102.1 R103.2 R406.2 U16.AB5
AUD_SPK_R+: CN3.40 R368.1
AUD_SPK_R+_C: CN5.1 EC61.2 R368.2
AUD_SPK_R-: CN3.39 R367.1
AUD_SPK_R-_C: CN5.2 EC60.1 R367.2
AUDIO_ALW: CN3.14 EC68.1 R471.2 R472.2
AUDIO_EN: PR115.1 Q22.2 R281.1 TP77.1 U16.P1
AUX_SINK_N_R: CN1.18 U2.6 U3.6
AUX_SINK_P_R: CN1.16 U2.3 U3.3
BAT_LED_WHITE: CN6.4 EC23.1 U4.N5
BAT_LED_YELLOW: CN6.3 EC24.1 U4.M5
BBS: R37.1 R43.1 R44.2 U16.L8
BEEP: CN3.46 U4.K7
BID0: R66.1 R73.2 U4.G10
BLED0: C268.1 Q31.2 R371.1 U4.D13
BLED1: C273.1 Q33.2 R384.1 U4.D6
BLED2: C276.1 Q34.2 R387.1 U4.G1
BLED3: C280.1 Q35.2 R394.1 U4.J6
BLED4: C180.1 Q20.2 R232.2 U4.A5
BLED_SW_IN0#: D2.3 SW1.1
BLED_SW_IN0#_R: D2.1 R47.1 U4.A3
BT_PCMCLK: CN4.8 U11.2
BT_PCMFR1: CN4.10 U11.3
BT_PCMIN: CN4.12 U11.5
BT_PCMOUT: CN4.14 U11.4
BT_RADIO_DIS#: Q13.1 R113.1 U16.AG6
BT_RADIO_DIS#_R: CN4.54 Q13.3 R215.1
BT_WAKE#: R171.2 R323.1 TP111.1 U16.AM3
BUF_PLT_RST#: R56.2 R142.1 R152.1 R487.1 U1.2 U4.M4 U9.4 U12.1 U14.1
BUF_PLT_RST#_TPM: R56.1 U1.4 U6.16
CAD_SINK#: CN1.4 Q2.2 R10.1 TP63.1 U3.1 U3.7
CAP_LED: Q14.2 R85.1 R207.1 U16.R6
CAP_LED_L: JKB1.27 R208.2
CATERR#: TP74.1 U16.K61
CFG0: R117.1 U16.AC60
CFG1: R109.1 U16.AC62
CFG2: TP103.1 U16.AC63
CFG3: R300.1 U16.AA63
CFG4: R101.1 U16.AA60
CFG5: TP98.1 U16.Y62
CFG6: TP99.1 U16.Y61
CFG7: TP104.1 U16.Y60
CFG8: R88.1 U16.V62
CFG9: R83.1 U16.V61
CFG10: R96.1 U16.V60
CFG11: TP100.1 U16.U60
CFG12: TP85.1 U16.T63
CFG13: TP90.1 U16.T62
CFG14: TP82.1 U16.T61
CFG15: TP19.1 U16.T60
CFG16: TP97.1 U16.AA62
CFG17: TP91.1 U16.U63
CFG18: TP102.1 U16.AA61
CFG19: TP92.1 U16.U62
CHARGER_AGND: PC68.2 PC69.2 PC82.2 PC85.2 PC86.2 PC90.2 PC95.2 PQ10.1 PR88.2 PU12.21 PU12.22 PU12.23 PU12.24 PU12.25 SJ5.1
CLK_33M_TPM_TPM: R53.1 U6.21
CLK_PCIE_WLANN: CN4.49 U16.C41
CLK_PCIE_WLANP: CN4.47 U16.B42
CLKDVCOM: J1.22 TP95.1
CLKRUN#: R58.2 R92.1 U4.D8 U16.V5
CLKRUN#_TPM: R57.1 R58.1 U6.15
CONFIG2: CN1.6 TP64.1
CRIT_TEMP_REP_N: R286.1 TP79.1 U16.T3
DATADVCOM: J1.9 TP17.1
DC_TEST_A3_B3: U16.A3 U16.B3
DC_TEST_A61_B61: U16.A61 U16.B61
DC_TEST_AY2_AW2: U16.AW2 U16.AY2
DC_TEST_AY3_AW3: U16.AW3 U16.AY3
DC_TEST_AY61_AW61: U16.AW61 U16.AY61
DC_TEST_AY62_AW62: U16.AW62 U16.AY62
DC_TEST_B62_B63: U16.B62 U16.B63
DC_TEST_C1_C2: U16.C1 U16.C2
DDC_EN#: Q2.3 R9.1 U2.1 U2.7
DDR3_DRAMRST#: C262.1 R356.1 U16.AV15 U18.T2 U19.T2 U20.T2 U21.T2 U22.T2 U23.T2 U24.T2 U25.T2
DDR_PG_CTRL: PR50.1 R345.2 U17.4
DEVSLP0: R267.1 U16.P2
DEVSLP1: RP4.1 TP145.1 U16.L2
DEVSLP2: CON1.44 R68.1 R474.1 U16.N5
DMIC_CLK: CN3.43 R309.2
DMIC_DATA: CN3.44 R308.2
DOCK_PSID: CN7.3 FL1.1
DP_UTIL: R258.1 R259.1 U16.A43
DPWROK: R20.1 R168.2
DPWROK_R: R163.1 R167.1 R168.1 U16.AV5
DQA_ZQ0: R393.1 U18.L8
DQA_ZQ1: R242.1 U18.L9
DQA_ZQ2: R398.1 U19.L8
DQA_ZQ3: R249.1 U19.L9
DQA_ZQ4: R403.1 U20.L8
DQA_ZQ5: R402.1 U20.L9
DQA_ZQ6: R396.1 U21.L8
DQA_ZQ7: R248.1 U21.L9
DQB_ZQ0: R397.1 U22.L8
DQB_ZQ1: R237.1 U22.L9
DQB_ZQ2: R399.1 U23.L8
DQB_ZQ3: R251.1 U23.L9
DQB_ZQ4: R400.1 U24.L8
DQB_ZQ5: R252.1 U24.L9
DQB_ZQ6: R401.1 U25.L8
DQB_ZQ7: R250.1 U25.L9
DSP_BITCLK: EC6.1 R174.2 R197.1
DSP_BITCLK_R: R174.1 U10.23
DSP_RST#: R209.1 U10.18
DSP_SDIN0: R202.1 U10.21
DSP_SDOUT: R194.1 U10.24
DSP_SYNC: R188.1 U10.19
DSWVRMEN: R362.2 U16.AW7
EAPD#: CN3.22 U4.M12
EC_SPI_CS#: RP28.2 U4.A7
EC_SPI_DIN: R7.1 RP28.6 U4.B6
EC_SPI_DO: R19.1 RP28.4 U4.A6
EC_SPI_SLK: RP28.8 U4.B5
EC_VCCST_PWRGD: R404.1 R406.1 U4.B8
EDP_AUXN: EL6.4 U16.A45
EDP_AUXN_C: C252.1 J1.31 R305.1
EDP_AUXN_R: C252.2 EL6.3
EDP_AUXP: EL6.1 U16.B45
EDP_AUXP_C: C253.1 J1.30 R306.1
EDP_AUXP_R: C253.2 EL6.2
EDP_COMP: R40.1 U16.D20
EDP_HPD: J1.33 R36.1 U16.D6
EDP_TXN0: EL3.4 U16.C45
EDP_TXN0_C: C248.1 J1.28
EDP_TXN0_R: C248.2 EL3.3
EDP_TXN1: EL4.4 U16.A47
EDP_TXN1_C: C250.1 J1.25
EDP_TXN1_R: C250.2 EL4.3
EDP_TXP0: EL3.1 U16.B46
EDP_TXP0_C: C249.1 J1.27
EDP_TXP0_R: C249.2 EL3.2
EDP_TXP1: EL4.1 U16.B47
EDP_TXP1_C: C251.1 J1.24
EDP_TXP1_R: C251.2 EL4.2
EN_LCDVCC: D9.3 R74.1 U5.3
ENVDD: D9.1 PR162.1 R257.1 U16.C6
FAN_PWM: CN3.16 U4.M6
FAN_PWR_EN_R: PR143.2 PR144.1 PU16.3
FAN_TACH: CN3.21 U4.M11
GPIO14: R116.1 TP31.1 U16.AH4
GPIO15: R108.1 U16.AD6
GPIO24: R100.1 U16.AD5
GPIO25: R476.1 U16.AM4
GPIO26: R329.1 U16.AN3
GPIO28: R107.1 TP23.1 U16.AD7
GPIO35: R287.1 TP80.1 U16.U1
GPIO36: R97.1 TP22.1 U16.V6
GPIO37: R301.1 TP94.1 U16.AC1
GPIO44: R127.1 U16.AK4
GPIO51: R84.1 U16.R5
GPIO52: R269.1 U16.L1
GPIO53: R276.1 U16.L4
GPIO54: R277.1 U16.L3
GPIO58: R124.1 U16.AL4
GPIO60: R325.1 U16.AL2
GPIO70: R34.1 U16.C4
GPIO73: RP7.1 TP34.1 U16.AU4
GPIO78: R78.1 U16.P4
GPIO79: R65.1 U16.N4
GPIO85: RP26.1 U16.N6
GPIO87: R91.1 U16.R7
GPIO90: R459.2 R460.1 U16.K2
GPIO91: R273.2 R274.1 U16.J1
GPIO92: R275.1 R278.2 U16.K3
GPIO93: R266.2 R268.1 U16.J2
GPIO94: RP26.3 U16.G1
H_CPU_SVIDALRT_N: R284.1 U16.L62
H_CPUPWRGD: R255.2 U16.C61
H_PROCHOT#: R279.2 U16.K63
H_PROCHOT#_EC: Q3.2 R17.1 U4.B11
H_VR_ENABLE_MCP: PR185.2 R262.1 U16.F60
HDA_BITCLK: R198.1 R199.1 R359.1
HDA_BITCLK_CODEC: CN3.10 R197.2 R198.2
HDA_BITCLK_DSP: C137.1 R199.2 U10.6
HDA_BITCLK_R: EC59.1 R359.2 U16.AW8
HDA_RST#: R178.1 R210.1 R211.1
HDA_RST#_CODEC: CN3.7 R209.2 R210.2
HDA_RST#_DSP: R211.2 U10.11
HDA_RST#_R: R178.2 U16.AU8
HDA_SDIN0: R203.1 R204.1 U16.AY10
HDA_SDIN0_CODEC: CN3.9 R202.2 R203.2
HDA_SDIN0_DSP: R138.2 R204.2
HDA_SDIN0_DSP_R: C133.1 R138.1 U10.8
HDA_SDOUT: R195.1 R196.1 R358.1
HDA_SDOUT_CODEC: CN3.11 R194.2 R195.2
HDA_SDOUT_DSP: C138.1 R196.2 U10.5
HDA_SDOUT_R: R357.2 R358.2 U16.AU11
HDA_SYNC: R175.1 R189.1 R190.1
HDA_SYNC_CODEC: CN3.8 R188.2 R189.2
HDA_SYNC_DSP: C124.1 R190.2 U10.10
HDA_SYNC_R: R175.2 R182.2 U16.AV11
HWPG: C8.1 R13.2 R23.2 R26.2 R103.1 R364.1 R404.2
I2C0_SCL: Q24.3 RP27.2 U16.F3
I2C0_SCL_DSP: Q24.4 RP9.1 U10.27
I2C0_SDA: Q24.6 RP27.4 U16.F2
I2C0_SDA_DSP: Q24.1 RP9.3 U10.26
I2C1_SCL: Q25.3 RP29.2 U16.F1
I2C1_SDA: Q25.6 RP29.4 U16.G4
I2S_BCLK_OUT: U10.29 U11.10
I2S_SDI_IN: U10.41 U11.7
I2S_SDO_OUT: U10.31 U11.8
I2S_SFRM_OUT: U10.30 U11.9
IFB1: J1.13 PR4.2 PR5.2
IFB2: J1.12 PR2.2 PR3.2
IFB3: J1.11 PR223.2 PR225.2
IFB4: J1.10 PR221.2 PR224.2
IINP: PC54.1 PC55.1 PC68.1 PR51.2 PU6.1 PU12.7 U4.F12
IMVP7_PROCHOT#: C156.1 PQ11.3 PR179.2 Q3.3 R279.1 R282.2 R283.2
IMVP_PWRGD: PC218.1 PD9.1 PR226.2 R262.2 U16.C59
INT_AUX_SINKN: C55.2 R71.1 R81.2 U3.5
INT_AUX_SINKP: C56.2 R11.1 R12.2 U3.2
INT_DP_AUXN: C55.1 U16.B6
INT_DP_AUXP: C56.1 U16.A6
INT_DP_HPD: Q1.1 R3.1 R14.1 U16.A8
INT_DP_HPD_R: CN1.2 Q1.3 R3.2 R4.1
INT_DP_SCL: RP3.1 U2.2 U16.D9
INT_DP_SDA: RP3.3 U2.5 U16.D11
INT_DP_TXN0: C7.2 CN1.5
INT_DP_TXN0_C: C7.1 U16.C51
INT_DP_TXN1: C16.2 CN1.11
INT_DP_TXN1_C: C16.1 U16.C53
INT_DP_TXN2: C20.2 CN1.17
INT_DP_TXN2_C: C20.1 U16.C49
INT_DP_TXN3: C244.2 CN1.12
INT_DP_TXN3_C: C244.1 U16.A53
INT_DP_TXP0: C10.2 CN1.3
INT_DP_TXP0_C: C10.1 U16.C50
INT_DP_TXP1: C13.2 CN1.9
INT_DP_TXP1_C: C13.1 U16.B54
INT_DP_TXP2: C43.2 CN1.15
INT_DP_TXP2_C: C43.1 U16.B50
INT_DP_TXP3: C243.2 CN1.10
INT_DP_TXP3_C: C243.1 U16.B53
IRQ_SERIRQ: R49.2 RP4.3 U4.G2 U16.T4
IRQ_SERIRQ_TPM: R49.1 U6.27
KB_BACKLITE_EN: Q21.2 U4.K6
KB_DET#: JKB1.1 R291.1 TP86.1 U16.Y1
KB_LED_DET: R28.1 R391.1 R392.1 U16.L6
KSI0: EC32.1 JKB1.9 U4.J12
KSI1: EC30.1 JKB1.7 U4.J13
KSI2: EC28.1 JKB1.5 U4.J9
KSI3: EC31.1 JKB1.8 U4.H12
KSI4: EC20.1 JKB1.4 U4.H9
KSI5: EC29.1 JKB1.6 U4.H10
KSI6: EC19.1 JKB1.3 U4.H13
KSI7: EC18.1 JKB1.2 U4.G9
KSO0: EC41.1 JKB1.18 U4.M8
KSO1: EC39.1 JKB1.16 U4.J7
KSO2: EC40.1 JKB1.17 U4.N9
KSO3: EC38.1 JKB1.15 U4.M9
KSO4: EC34.1 JKB1.11 U4.K8
KSO5: EC33.1 JKB1.10 U4.J8
KSO6: EC36.1 JKB1.13 U4.N10
KSO7: EC35.1 JKB1.12 U4.M10
KSO8: EC37.1 JKB1.14 U4.N11
KSO9: EC47.1 JKB1.24 U4.K9
KSO10: EC49.1 JKB1.26 U4.N12
KSO11: EC48.1 JKB1.25 U4.N13
KSO12: EC42.1 JKB1.19 U4.M13
KSO13: EC45.1 JKB1.22 U4.L12
KSO14: EC46.1 JKB1.23 U4.L13
KSO15: EC44.1 JKB1.21 U4.K12
KSO16: EC43.1 JKB1.20 U4.K13
LATCH: C9.1 D2.2 D3.1 D5.1 D7.1 Q4.5 Q4.6 Q5.3 R41.2
LCD_BAK: PR164.1 U4.N8
LCD_CE: J1.20 R98.1 TP21.1 U16.U4
LCD_DBC: J1.14 R302.1 TP96.1 U16.Y3
LCD_PWM: D24.1 R258.2 U16.B8
LCD_PWM_EC: D24.2 U4.N6
LCD_PWM_IN: D24.3 J1.15 R330.1
LCD_PWM_OUT: J1.19 PR7.1
LCD_TST: D9.2 J1.34 U4.B10
LED#2: CN4.16 TP122.1
LED_PWM: J2.1 Q21.3
LID_SW#: C167.1 CN6.5 EC22.1 R77.1 R223.2 U4.C2
LPC_CLK_0: R139.1 U16.AN15
LPC_CLK_1: EC3.1 R154.1 R158.1 U16.AP15
LPC_CLK_DEBUG: R154.2 R240.2
LPC_CLK_DEBUG_R: CN4.70 R240.1
LPC_CLK_EC: EC4.1 R139.2 U4.K2
LPC_CLK_TPM: EC1.1 R53.2 R158.2
LPC_LAD0: R50.2 R219.2 U4.K1 U16.AU14
LPC_LAD0_R: CN4.58 R219.1
LPC_LAD0_TPM: R50.1 U6.26
LPC_LAD1: R51.2 R221.2 U4.J2 U16.AW12
LPC_LAD1_R: CN4.60 R221.1
LPC_LAD1_TPM: R51.1 U6.23
LPC_LAD2: R54.2 R224.2 U4.J1 U16.AY12
LPC_LAD2_R: CN4.62 R224.1
LPC_LAD2_TPM: R54.1 U6.20
LPC_LAD3: R55.2 R227.2 U4.H2 U16.AW11
LPC_LAD3_R: CN4.64 R227.1
LPC_LAD3_TPM: R55.1 U6.17
LPC_LFRAME#: R52.2 R231.2 U4.H1 U16.AV12
LPC_LFRAME#_R: CN4.66 R231.1
LPC_LFRAME#_TPM: R52.1 U6.22
M_A_A0: R412.2 U16.AU36 U18.N3 U19.N3 U20.N3 U21.N3
M_A_A1: R417.2 U16.AY37 U18.P7 U19.P7 U20.P7 U21.P7
M_A_A2: R425.2 U16.AR38 U18.P3 U19.P3 U20.P3 U21.P3
M_A_A3: R414.2 U16.AP36 U18.N2 U19.N2 U20.N2 U21.N2
M_A_A4: R419.2 U16.AU39 U18.P8 U19.P8 U20.P8 U21.P8
M_A_A5: R427.2 U16.AR36 U18.P2 U19.P2 U20.P2 U21.P2
M_A_A6: R416.2 U16.AV40 U18.R8 U19.R8 U20.R8 U21.R8
M_A_A7: R418.2 U16.AW39 U18.R2 U19.R2 U20.R2 U21.R2
M_A_A8: R420.2 U16.AY39 U18.T8 U19.T8 U20.T8 U21.T8
M_A_A9: R426.2 U16.AU40 U18.R3 U19.R3 U20.R3 U21.R3
M_A_A10: R411.2 U16.AP35 U18.L7 U19.L7 U20.L7 U21.L7
M_A_A11: R422.2 U16.AW41 U18.R7 U19.R7 U20.R7 U21.R7
M_A_A12: R423.2 U16.AU41 U18.N7 U19.N7 U20.N7 U21.N7
M_A_A13: R415.2 U16.AR35 U18.T3 U19.T3 U20.T3 U21.T3
M_A_A14: R421.2 U16.AV42 U18.T7 U19.T7 U20.T7 U21.T7
M_A_A15: R424.2 U16.AU42 U18.M7 U19.M7 U20.M7 U21.M7
M_A_BS0: R429.2 U16.AU35 U18.M2 U19.M2 U20.M2 U21.M2
M_A_BS1: R428.2 U16.AV35 U18.N8 U19.N8 U20.N8 U21.N8
M_A_BS2: R413.2 U16.AY41 U18.M3 U19.M3 U20.M3 U21.M3
M_A_CAS#: R432.2 U16.AU34 U18.K3 U19.K3 U20.K3 U21.K3
M_A_CKE0: R433.2 U16.AU43 U18.K9 U19.K9 U20.K9 U21.K9
M_A_CKE1: R434.2 U16.AW43 U18.J9 U19.J9 U20.J9 U21.J9
M_A_CLKN0: R228.1 U16.AU37 U18.K7 U19.K7 U20.K7 U21.K7
M_A_CLKP0: R225.1 U16.AV37 U18.J7 U19.J7 U20.J7 U21.J7
M_A_CS#0: R239.2 U16.AP33 U18.L2 U19.L2 U20.L2 U21.L2
M_A_CS#1: R236.2 U16.AR32 U18.L1 U19.L1 U20.L1 U21.L1
M_A_DQ0: U16.AH63 U18.H7
M_A_DQ1: U16.AH62 U18.F7
M_A_DQ2: U16.AK63 U18.E3
M_A_DQ3: U16.AK62 U18.H3
M_A_DQ4: U16.AH61 U18.F8
M_A_DQ5: U16.AH60 U18.H8
M_A_DQ6: U16.AK61 U18.F2
M_A_DQ7: U16.AK60 U18.G2
M_A_DQ8: U16.AM63 U18.C8
M_A_DQ9: U16.AM62 U18.B8
M_A_DQ10: U16.AP63 U18.C3
M_A_DQ11: U16.AP62 U18.C2
M_A_DQ12: U16.AM61 U18.A7
M_A_DQ13: U16.AM60 U18.D7
M_A_DQ14: U16.AP61 U18.A2
M_A_DQ15: U16.AP60 U18.A3
M_A_DQ16: U16.AP58 U19.E3
M_A_DQ17: U16.AR58 U19.F2
M_A_DQ18: U16.AM57 U19.H7
M_A_DQ19: U16.AK57 U19.F8
M_A_DQ20: U16.AL58 U19.F7
M_A_DQ21: U16.AK58 U19.H8
M_A_DQ22: U16.AR57 U19.G2
M_A_DQ23: U16.AN57 U19.H3
M_A_DQ24: U16.AP55 U19.D7
M_A_DQ25: U16.AR55 U19.A7
M_A_DQ26: U16.AM54 U19.A2
M_A_DQ27: U16.AK54 U19.C2
M_A_DQ28: U16.AL55 U19.B8
M_A_DQ29: U16.AK55 U19.C8
M_A_DQ30: U16.AR54 U19.C3
M_A_DQ31: U16.AN54 U19.A3
M_A_DQ32: U16.AY58 U20.F8
M_A_DQ33: U16.AW58 U20.F7
M_A_DQ34: U16.AY56 U20.E3
M_A_DQ35: U16.AW56 U20.H3
M_A_DQ36: U16.AV58 U20.H7
M_A_DQ37: U16.AU58 U20.H8
M_A_DQ38: U16.AV56 U20.F2
M_A_DQ39: U16.AU56 U20.G2
M_A_DQ40: U16.AY54 U20.D7
M_A_DQ41: U16.AW54 U20.A7
M_A_DQ42: U16.AY52 U20.A2
M_A_DQ43: U16.AW52 U20.C2
M_A_DQ44: U16.AV54 U20.B8
M_A_DQ45: U16.AU54 U20.C8
M_A_DQ46: U16.AV52 U20.A3
M_A_DQ47: U16.AU52 U20.C3
M_A_DQ48: U16.AK40 U21.G2
M_A_DQ49: U16.AK42 U21.H3
M_A_DQ50: U16.AM43 U21.H7
M_A_DQ51: U16.AM45 U21.F7
M_A_DQ52: U16.AK45 U21.F8
M_A_DQ53: U16.AK43 U21.H8
M_A_DQ54: U16.AM40 U21.F2
M_A_DQ55: U16.AM42 U21.E3
M_A_DQ56: U16.AM46 U21.C2
M_A_DQ57: U16.AK46 U21.A3
M_A_DQ58: U16.AM49 U21.A7
M_A_DQ59: U16.AK49 U21.D7
M_A_DQ60: U16.AM48 U21.C3
M_A_DQ61: U16.AK48 U21.A2
M_A_DQ62: U16.AM51 U21.B8
M_A_DQ63: U16.AK51 U21.C8
M_A_DQSN0: U16.AJ61 U18.G3
M_A_DQSN1: U16.AN62 U18.B7
M_A_DQSN2: U16.AM58 U19.G3
M_A_DQSN3: U16.AM55 U19.B7
M_A_DQSN4: U16.AV57 U20.G3
M_A_DQSN5: U16.AV53 U20.B7
M_A_DQSN6: U16.AL43 U21.G3
M_A_DQSN7: U16.AL48 U21.B7
M_A_DQSP0: U16.AJ62 U18.F3
M_A_DQSP1: U16.AN61 U18.C7
M_A_DQSP2: U16.AN58 U19.F3
M_A_DQSP3: U16.AN55 U19.C7
M_A_DQSP4: U16.AW57 U20.F3
M_A_DQSP5: U16.AW53 U20.C7
M_A_DQSP6: U16.AL42 U21.F3
M_A_DQSP7: U16.AL49 U21.C7
M_A_ODT: R244.1 U18.J1 U18.K1 U19.J1 U19.K1 U20.J1 U20.K1 U21.J1 U21.K1
M_A_RAS#: R431.2 U16.AY34 U18.J3 U19.J3 U20.J3 U21.J3
M_A_WE#: R430.2 U16.AW34 U18.L3 U19.L3 U20.L3 U21.L3
M_B_A0: R443.2 U16.AP40 U22.N3 U23.N3 U24.N3 U25.N3
M_B_A1: R436.2 U16.AR40 U22.P7 U23.P7 U24.P7 U25.P7
M_B_A2: R437.2 U16.AP42 U22.P3 U23.P3 U24.P3 U25.P3
M_B_A3: R451.2 U16.AR42 U22.N2 U23.N2 U24.N2 U25.N2
M_B_A4: R450.2 U16.AR45 U22.P8 U23.P8 U24.P8 U25.P8
M_B_A5: R454.2 U16.AP45 U22.P2 U23.P2 U24.P2 U25.P2
M_B_A6: R441.2 U16.AW46 U22.R8 U23.R8 U24.R8 U25.R8
M_B_A7: R448.2 U16.AY46 U22.R2 U23.R2 U24.R2 U25.R2
M_B_A8: R439.2 U16.AY47 U22.T8 U23.T8 U24.T8 U25.T8
M_B_A9: R449.2 U16.AU46 U22.R3 U23.R3 U24.R3 U25.R3
M_B_A10: R445.2 U16.AK36 U22.L7 U23.L7 U24.L7 U25.L7
M_B_A11: R440.2 U16.AV47 U22.R7 U23.R7 U24.R7 U25.R7
M_B_A12: R447.2 U16.AU47 U22.N7 U23.N7 U24.N7 U25.N7
M_B_A13: R442.2 U16.AK33 U22.T3 U23.T3 U24.T3 U25.T3
M_B_A14: R435.2 U16.AR46 U22.T7 U23.T7 U24.T7 U25.T7
M_B_A15: R452.2 U16.AP46 U22.M7 U23.M7 U24.M7 U25.M7
M_B_BS0: R444.2 U16.AL35 U22.M2 U23.M2 U24.M2 U25.M2
M_B_BS1: R438.2 U16.AM36 U22.N8 U23.N8 U24.N8 U25.N8
M_B_BS2: R453.2 U16.AU49 U22.M3 U23.M3 U24.M3 U25.M3
M_B_CAS#: R455.2 U16.AM33 U22.K3 U23.K3 U24.K3 U25.K3
M_B_CKE0: R457.2 U16.AY49 U22.K9 U23.K9 U24.K9 U25.K9
M_B_CKE1: R458.2 U16.AU50 U22.J9 U23.J9 U24.J9 U25.J9
M_B_CLKN0: R234.1 U16.AM38 U22.K7 U23.K7 U24.K7 U25.K7
M_B_CLKP0: R233.1 U16.AN38 U22.J7 U23.J7 U24.J7 U25.J7
M_B_CS#0: R235.2 U16.AM32 U22.L2 U23.L2 U24.L2 U25.L2
M_B_CS#1: R230.2 U16.AK32 U22.L1 U23.L1 U24.L1 U25.L1
M_B_DQ0: U16.AY31 U22.H7
M_B_DQ1: U16.AW31 U22.F7
M_B_DQ2: U16.AY29 U22.F2
M_B_DQ3: U16.AW29 U22.H3
M_B_DQ4: U16.AV31 U22.F8
M_B_DQ5: U16.AU31 U22.H8
M_B_DQ6: U16.AV29 U22.G2
M_B_DQ7: U16.AU29 U22.E3
M_B_DQ8: U16.AY27 U22.D7
M_B_DQ9: U16.AW27 U22.A7
M_B_DQ10: U16.AY25 U22.A2
M_B_DQ11: U16.AW25 U22.C2
M_B_DQ12: U16.AV27 U22.B8
M_B_DQ13: U16.AU27 U22.C8
M_B_DQ14: U16.AV25 U22.A3
M_B_DQ15: U16.AU25 U22.C3
M_B_DQ16: U16.AM29 U23.F8
M_B_DQ17: U16.AK29 U23.F7
M_B_DQ18: U16.AL28 U23.F2
M_B_DQ19: U16.AK28 U23.G2
M_B_DQ20: U16.AR29 U23.H7
M_B_DQ21: U16.AN29 U23.H8
M_B_DQ22: U16.AR28 U23.E3
M_B_DQ23: U16.AP28 U23.H3
M_B_DQ24: U16.AN26 U23.D7
M_B_DQ25: U16.AR26 U23.A7
M_B_DQ26: U16.AR25 U23.C3
M_B_DQ27: U16.AP25 U23.C2
M_B_DQ28: U16.AK26 U23.C8
M_B_DQ29: U16.AM26 U23.B8
M_B_DQ30: U16.AK25 U23.A2
M_B_DQ31: U16.AL25 U23.A3
M_B_DQ32: U16.AY23 U24.F8
M_B_DQ33: U16.AW23 U24.F7
M_B_DQ34: U16.AY21 U24.E3
M_B_DQ35: U16.AW21 U24.H3
M_B_DQ36: U16.AV23 U24.H8
M_B_DQ37: U16.AU23 U24.H7
M_B_DQ38: U16.AV21 U24.F2
M_B_DQ39: U16.AU21 U24.G2
M_B_DQ40: U16.AY19 U24.D7
M_B_DQ41: U16.AW19 U24.C8
M_B_DQ42: U16.AY17 U24.C3
M_B_DQ43: U16.AW17 U24.C2
M_B_DQ44: U16.AV19 U24.A7
M_B_DQ45: U16.AU19 U24.B8
M_B_DQ46: U16.AV17 U24.A2
M_B_DQ47: U16.AU17 U24.A3
M_B_DQ48: U16.AR21 U25.E3
M_B_DQ49: U16.AR22 U25.F7
M_B_DQ50: U16.AL21 U25.F2
M_B_DQ51: U16.AM22 U25.F8
M_B_DQ52: U16.AN22 U25.H8
M_B_DQ53: U16.AP21 U25.H3
M_B_DQ54: U16.AK21 U25.G2
M_B_DQ55: U16.AK22 U25.H7
M_B_DQ56: U16.AN20 U25.D7
M_B_DQ57: U16.AR20 U25.A7
M_B_DQ58: U16.AK18 U25.A2
M_B_DQ59: U16.AL18 U25.C2
M_B_DQ60: U16.AK20 U25.C8
M_B_DQ61: U16.AM20 U25.B8
M_B_DQ62: U16.AR18 U25.C3
M_B_DQ63: U16.AP18 U25.A3
M_B_DQSN0: U16.AW30 U22.G3
M_B_DQSN1: U16.AV26 U22.B7
M_B_DQSN2: U16.AN28 U23.G3
M_B_DQSN3: U16.AN25 U23.B7
M_B_DQSN4: U16.AW22 U24.G3
M_B_DQSN5: U16.AV18 U24.B7
M_B_DQSN6: U16.AN21 U25.G3
M_B_DQSN7: U16.AN18 U25.B7
M_B_DQSP0: U16.AV30 U22.F3
M_B_DQSP1: U16.AW26 U22.C7
M_B_DQSP2: U16.AM28 U23.F3
M_B_DQSP3: U16.AM25 U23.C7
M_B_DQSP4: U16.AV22 U24.F3
M_B_DQSP5: U16.AW18 U24.C7
M_B_DQSP6: U16.AM21 U25.F3
M_B_DQSP7: U16.AM18 U25.C7
M_B_ODT: R247.1 U22.J1 U22.K1 U23.J1 U23.K1 U24.J1 U24.K1 U25.J1 U25.K1
M_B_RAS#: R456.2 U16.AM35 U22.J3 U23.J3 U24.J3 U25.J3
M_B_WE#: R446.2 U16.AK35 U22.L3 U23.L3 U24.L3 U25.L3
MCP_RSVD_19: TP114.1 U16.AV63
MCP_RSVD_20: TP115.1 U16.AU63
MCP_RSVD_21: TP67.1 U16.C63
MCP_RSVD_22: TP68.1 U16.C62
MCP_RSVD_23: TP49.1 U16.B43
MCP_RSVD_24: TP59.1 U16.A51
MCP_RSVD_25: TP54.1 U16.B51
MCP_RSVD_26: TP12.1 U16.L60
MCP_RSVD_69: TP20.1 U16.P60
MCP_RSVD_70: TP14.1 U16.P61
MCP_RSVD_71: TP18.1 U16.N59
MCP_RSVD_72: TP11.1 U16.N61
ME_SUS_PWR_ACK: R145.1 U4.G12
ME_SUS_PWR_ACK_R: R144.1 R145.2 R319.1 U16.AV4
MODPHY_EN: D10.2 PR48.1 U16.Y2
MPCIE_RST_N: R183.2 U12.2 U14.2 U16.U6
NB_MUTE#: CN3.48 R464.1 U4.B12
NGFF_PCIE_WLAN_WAKE_R#: CN4.55 Q43.2 Q44.2 R187.2 R193.2 R212.1
NGFF_SATA_SSD_PWREN: PR94.1 R37.2
NGFF_WLAN_PCIE_RST#: CN4.52 R191.1 R487.2 U14.4
NGFF_WLAN_PWR_EN: D25.1 R114.1 R118.1
NGFF_WLAN_PWR_EN_EC: D25.2 U4.B7
NGFF_WLAN_PWR_EN_R: PR96.1 PR232.1 PU9.5
NGFF_WLAN_SDIO_RST#: CN4.23 R170.2 U12.4
NOA_RCOMP: R298.2 U16.V63
OZ9955H_CMP: PC4.1 PR18.1 PU1.22
OZ9955H_DIM: PC1.1 PR6.1 PR7.2 PU1.6
OZ9955H_ENA: PC147.1 PR161.1 PR162.2 PR163.2 PR164.2 PU1.1
OZ9955H_FSET: PR14.2 PR16.1 PU1.2
OZ9955H_IFB1: PR5.1 PU1.7
OZ9955H_IFB2: PR4.1 PU1.8
OZ9955H_IFB3: PR3.1 PU1.9
OZ9955H_IFB4: PR2.1 PU1.10
OZ9955H_IFB5: PR225.1 PU1.12
OZ9955H_IFB6: PR223.1 PU1.13
OZ9955H_IFB7: PR221.1 PU1.14
OZ9955H_IFB8: PR224.1 PU1.15
OZ9955H_ISET: PR1.1 PU1.11
OZ9955H_LCT: PR12.1 PU1.3
OZ9955H_OVP: PR10.1 PR13.2 PU1.16
OZ9955H_SW: PD8.2 PL2.2 PU1.19 PU1.20
OZ9955H_VREF: PC3.1 PR11.1 PR14.1 PU1.24
OZ9955H_VSCP: PR9.1 PR11.2 PU1.4
PANEL_BKEN: PR163.1 U4.F13 U16.A9
PBAT_ALERT#: ESD2.3 PR133.1 PR140.2 U4.D1
PBAT_PRES#: ESD2.1 PR134.2 PR141.2 U4.F10
PCH_EDM: R353.1 TP135.1 U16.AV2
PCH_GPIO80: R270.1 U16.N2
PCH_INTVRMEN: R360.1 R361.2 U16.AV7
PCH_JTAG_TDO: R132.2 TP113.1 U16.AE61
PCH_JTAGX: R135.1 R405.2 U16.AE63
PCH_MELOCK: R357.1 U4.A11
PCH_OPIICCCTL: TP26.1 U16.AF20
PCH_OPIICCOBS: TP25.1 U16.AB21
PCH_OPIRCOMP: R354.1 U16.AW15
PCH_PWROK: R363.1 R364.2 U16.AY7
PCH_SATA_LED#: R94.1 U16.U3
PCH_SMB_ALERT#: RP7.3 U16.AN2
PCH_SPI_CLK: EC2.2 R307.1 U16.AA3
PCH_SPI_CS0#: R294.1 U16.Y7
PCH_SPI_IO2: R304.1 U16.Y6
PCH_SPI_IO3: R303.1 U16.AF1
PCH_SPI_SI: R313.1 U16.AA2
PCH_SPI_SO: R299.1 U16.AA4
PCH_THRMTRIP#: R253.2 U16.D60
PCI_PME_N: TP93.1 U16.AD4
PCIE_CLK_REQ0#: RP31.5 TP89.1 U16.U2
PCIE_CLK_REQ1#: RP31.3 U16.Y5
PCIE_CLK_REQ2#: Q42.3 R213.1 RP31.1 U16.AD1
PCIE_CLK_REQ2#_R: CN4.53 Q42.2 R200.1 R213.2
PCIE_CLK_REQ3#: RP31.7 TP87.1 U16.N1
PCIE_CLK_REQ4#: RP30.1 TP84.1 U16.U5
PCIE_CLK_REQ5#: RP30.3 U16.T2
PCIE_IREF: R27.2 U16.B27
PCIE_PLLOBS1: TP5.1 U16.E13
PCIE_RCOMP: R25.2 U16.A27
PCIE_RXN3: CN4.43 U16.G11
PCIE_RXP3: CN4.41 U16.F11
PCIE_SLOT3_WAKE_N: Q44.3 R193.1 R347.1 R385.1 TP120.1 U16.AU2
PCIE_TXN3: C240.1 CN4.37
PCIE_TXN3_C: C240.2 U16.C29
PCIE_TXP3: C241.1 CN4.35
PCIE_TXP3_C: C241.2 U16.B30
PCIE_WAKE#: Q43.3 R314.2
PCIE_WAKE#_R: R314.1 R318.1 U16.AJ5
PECI_EC: R30.1 U4.B1
PECI_EC_R: R30.2 U16.N62
PLTRST#: R152.2 R238.2 U9.1 U9.2 U16.AG7
PLTRST#_R: CN4.68 R238.1
PM_BATLOW#: Q29.1 R349.1 U16.AN4
PM_BATLOW_N: Q29.3 R344.2 U4.F1
PM_TEST_RST_N: TP24.1 U16.AC4
POWER_SW_IN0#: CN3.20 D3.3 R18.1 R475.2
PROC_DETECT#: TP50.1 U16.D61
PROC_OPI_COMP: R355.1 U16.AY15
PS/2_CLK_TPAD: EC10.1 L4.1 RP11.2 U4.D9
PS/2_DAT_TPAD: EC11.1 L5.1 RP11.4 U4.B9
PS_ID: PD6.3 PR148.2 PR149.2 U4.A10
PWR_DEBUG#: R1.1 TP57.1 U16.H59
REFPKG_OCC: R265.1 U16.A5
REGN_LDO: PC95.1 PD5.2 PR102.1 PU12.16
REM_DIODE1_N: C74.2 C132.2 Q6.1 U8.3
REM_DIODE1_P: C74.1 C132.1 Q6.2 Q6.3 U8.2
REM_DIODE2_N: C168.2 C169.2 Q17.1 U8.5
REM_DIODE2_P: C168.1 C169.1 Q17.2 Q17.3 U8.4
RFLED#: CN4.6 TP121.1
RSMRST#: R166.1 R167.2 U4.B13 U16.AW6
RSVD_PGDMON: R120.1 TP29.1 U16.AL11
RTC_RST#: C161.1 R179.1 U16.AU7
RTC_X1: C261.2 R366.1 U16.AW5 Y3.1
RTC_X2: C267.2 R366.2 U16.AY5 Y3.4
RUN_ON: D11.2 PR32.1 PR84.1 PR128.1 PR198.1 PR230.1 Q38.2 R264.1 U4.D2
RUN_ON_R: D10.1 D11.1 PC15.1 PR32.2 PU2.3 PU2.5
SATA_IREF: R263.1 U16.A12
SATA_PLLOBS0: TP7.1 U16.L11
SATA_PLLOBS1: TP6.1 U16.K10
SATA_RCOMP: R254.1 U16.C12
SATA_RXN2: C89.1 U16.J6
SATA_RXN2_C: C89.2 CON1.25
SATA_RXP2: C83.1 U16.H6
SATA_RXP2_C: C83.2 CON1.23
SATA_TXN2: C102.2 U16.B14
SATA_TXN2_C: C102.1 CON1.31
SATA_TXP2: C111.2 U16.C15
SATA_TXP2_C: C111.1 CON1.33
SDIO_CLK: R336.1 R461.1 R478.1 RP35.3 U16.E3
SDIO_CMD: R337.1 R479.1 RP35.1 U16.F4
SDIO_D0: R271.1 R272.2 R338.1 R480.1 U16.D3
SDIO_D1: R339.1 R481.1 RP36.3 U16.E4
SDIO_D2: R340.1 R482.1 RP36.1 U16.C3
SDIO_D3: R341.1 R477.1 R483.1 U16.E2
SDIO_WLAN_WAKE: CN4.21 Q32.1 R370.2
SDIO_WLAN_WAKE_L: R369.2 R386.1 U16.AB6
SIO_EXT_SCI#: D15.2 R326.1 TP112.1 U16.AM2
SIO_PWRBTN#: D1.2 R348.1 U16.AL7
SIO_RCIN#: D14.2 R86.1 U16.V4
SIO_SLP_A#: TP33.1 U16.AL5
SIO_SLP_LAN#: TP117.1 U16.AJ7
SIO_SLP_S3#: PR55.1 U4.E1 U16.AT4
SIO_SLP_S4#: PR66.1 PR212.1 U4.N2 U16.AJ6
SIO_SLP_S5#: D4.2 PR75.1 U16.AP5
SIO_WAKE_SCI#: D16.2 R131.1 U16.AN5
SLP_S0#: PQ2.2 PR173.1 U16.AF3
SLP_S0#_P: PR173.2 PU17.2
SLP_SUS: Q8.3 Q9.2 R165.2
SLP_SUS#: PR174.1 PR213.1 Q8.2 U4.G13 U16.AP4
SLP_WLAN: R332.1 TP118.1 U16.AM5
SM_INTRUDER#: R365.2 U16.AU6
SM_RCOMP_0: R149.2 U16.AU60
SM_RCOMP_1: R155.2 U16.AV60
SM_RCOMP_2: R151.2 U16.AU61
SM_VREF_CA: C271.1 R373.1 U16.AP49
SM_VREF_DQ0: C270.1 R372.1 U16.AR51
SM_VREF_DQ1: C272.1 R374.1 U16.AP51
SMB_CLK_ME1: Q28.4 RP6.1 U16.AU3
SMB_DATA_ME1: Q28.1 RP6.3 U16.AH3
SMBCLK: Q26.3 R316.2 RP8.1 U16.AP2
SMBCLK0: ESD2.6 PR86.2 PR139.2 RP2.3 U4.B4
SMBCLK0_B: JBAT1.B7 PR139.1
SMBCLK0_P: PR86.1 PU12.9
SMBCLK1: Q28.3 RP1.3 U4.B3
SMBCLK3: Q16.3 Q27.3 R222.2 R333.2 RP5.3 U4.E8
SMBCLK3_Q: Q16.4 R222.1 RP14.2 U8.10
SMBCLK3_R: J1.17 Q26.4 Q27.4 R316.1 R333.1 RP32.2
SMBDAT0: ESD2.4 PR87.2 PR138.2 RP2.1 U4.A2
SMBDAT0_B: JBAT1.B6 PR138.1
SMBDAT0_P: PR87.1 PU12.8
SMBDAT1: Q28.6 RP1.1 U4.B2
SMBDAT3: Q16.6 Q27.6 R218.2 R320.2 RP5.1 U4.D7
SMBDAT3_Q: Q16.1 R218.1 RP14.4 U8.9
SMBDAT3_R: J1.16 Q26.1 Q27.1 R320.1 R331.1 RP32.4
SMBDATA: Q26.6 R331.2 RP8.3 U16.AH1
SMC_EXTSMI_N: D13.2 R292.1 TP83.1 U16.V1
SML0CLK: R328.1 U16.AN1
SML0DATA: R322.1 U16.AK1
SPI_CS#: R294.2 RP28.1 U15.1
SPI_SCK: R307.2 RP28.7 U15.6
SPI_SI: R313.2 RP28.5 U15.5
SPI_SO: R299.2 RP28.3 U15.2
SRTC_RST#: C162.1 R180.1 U16.AV6
SSD_PWREN: PR94.2 PR95.1 PU9.3
SUS_ON: PR40.1 PR120.1 PR175.1 Q40.2 R6.1 R16.1 U4.E7
SUSACK#: R324.1 U4.C13
SUSACK#_R: R319.2 R324.2 U16.AK2
SUSCLK: R205.2 U16.AE6
SWR_GND: C139.2 C144.2 C146.2 C148.2 C150.2 C154.2 C155.2 R150.2 U10.12
SYS_PWR_SW#: C15.1 D3.2 R21.2 U4.E2
SYS_PWROK: R311.1 U4.J10
SYS_PWROK_R: R310.1 R311.2 U16.AG2
SYS_RESET#: R295.1 R296.1 TP88.1 U16.AC3
SYS_SHDN#: Q7.1 R136.2 U8.7
T_CPU: R8.2 RT1.2 U4.F9
TD_IREF: R2.2 U16.B12
TESTLOW_0: RP25.1 U16.C35
TESTLOW_1: RP25.3 U16.C34
TESTLOW_2: RP25.5 U16.AK8
TESTLOW_3: RP25.7 U16.AL8
THERM_ALERT#: R137.2 U8.8
THERM_STP#: D6.1 PQ1.2 Q7.3 R75.2
THERMAL_PWR_EN: PR143.1 PR146.2 U4.E12
THERMAL_PWR_EN_R: PR145.1 PR146.1 PU16.5
THERMAL_STP#_CTRL: R160.1 U4.D12
TOUCH_PAD_CLK: Q25.4 R389.1 RP10.2
TOUCH_PAD_CLK_R: JP1.3 R389.2
TOUCH_PAD_DAT: Q25.1 R390.1 RP10.4
TOUCH_PAD_DAT_R: JP1.2 R390.2
TOUCHPAD_EN: PR110.1 R69.2 R79.2 R87.1
TOUCHPAD_EN_R: PR110.2 PR111.1 PU14.5
TOUCHPAD_INTR#: Q36.1 R388.1 R395.2
TOUCHPAD_INTR#_PCH: Q36.3 R93.1 U16.U7
TOUCHSCREEN_EN: PR67.1 R79.1 U16.N7
TOUCHSCREEN_EN_R: PR67.2 PR68.1 PU5.3
TOUCHSCREEN_SLEEP#: D8.2 JP2.6 R59.2
TOUCHSCREEN_SLP#: R76.1 U4.C1
TP_CLK: JP1.8 L4.2
TP_DATA: JP1.7 L5.2
TP_DC_TEST_A4: TP48.1 U16.A4
TP_DC_TEST_A60: TP51.1 U16.A60
TP_DC_TEST_A62: TP58.1 U16.A62
TP_DC_TEST_AV1: TP130.1 U16.AV1
TP_DC_TEST_AW1: TP138.1 U16.AW1
TP_DC_TEST_AW63: TP132.1 U16.AW63
TP_DC_TEST_AY60: TP131.1 U16.AY60
TP_DC_TEST_B2: TP2.1 U16.B2
TPM_LPC_PD: R48.2 R315.2 U6.28
TPM_PWR_EN: PR38.1 R143.1 U16.AG5
TPM_RST#: U1.1 U16.AP1
UART1_CTS: RP34.3 U13.7 U16.J4
UART1_CTS_R: CN4.34 R192.1 U13.5
UART1_RTS: RP34.1 U13.8 U16.J3
UART1_RTS_R: CN4.36 R186.1 U13.4
UART1_RX: RP33.1 U13.9 U16.K4
UART1_RX_R: CN4.22 R184.1 U13.3
UART1_TX: RP33.3 U13.10 U16.G2
UART1_TX_R: CN4.32 R173.1 U13.2
USB2_CAM_PWR_EN: PR70.2 R280.1 U16.P3
USB2_CAM_PWR_EN_R: PR69.1 PR70.1 PU5.5
USB3.0_RX1+: R334.1 U16.H20
USB3.0_RX1+_R: CN2.6 EU1.4 EU1.7 R334.2
USB3.0_RX1-: R335.1 U16.G20
USB3.0_RX1-_R: CN2.5 EU1.5 EU1.6 R335.2
USB3.0_RX2+: CN3.30 U16.F18
USB3.0_RX2-: CN3.29 U16.E18
USB3.0_TX1+: C255.1 U16.B34
USB3.0_TX1+_C: C255.2 R321.1
USB3.0_TX1+_R: C254.1 CN2.9 EU1.1 EU1.10 R321.2
USB3.0_TX1-: C256.1 U16.C33
USB3.0_TX1-_C: C256.2 R327.1
USB3.0_TX1-_R: C257.1 CN2.8 EU1.2 EU1.9 R327.2
USB3.0_TX2+: CN3.33 U16.A33
USB3.0_TX2-: CN3.32 U16.B33
USB3_P0_EN: R156.1 R157.1 U16.AT3
USB3_P0_EN_EC: C130.2 U4.A13 U7.5
USB3_P1_EN: R350.1 R351.1 TP123.1 U16.AV3
USB3_P1_EN_EC: CN3.18 U4.M2
USB_BIAS: R126.1 U16.AJ10 U16.AJ11
USB_BUS_SW0_CT1: C131.2 U4.A8 U7.6
USB_BUS_SW1_CT1: CN3.19 U4.N1
USB_CHG_DET0#: CN2.10 D7.3
USB_CHG_DET0#_R: D7.2 R89.2 U4.M1
USB_CHG_DET1#: CN3.15 D5.3
USB_CHG_DET1#_R: D5.2 R72.2 U4.F2
USB_OC0#: R106.2 R119.1 R121.1 TP32.1 U7.13 U16.AL3
USB_OC1#: CN3.17 R342.1 R343.1 TP119.1 U16.AT1
USB_OC2#: R317.1 TP107.1 U16.AH2
USBP0+: U7.3 U16.AM8
USBP0+_L: CN2.3 EL1.3 ESD1.3
USBP0+_R: EL1.4 U7.10
USBP0-: U7.2 U16.AN8
USBP0-_L: CN2.2 EL1.2 ESD1.1
USBP0-_R: EL1.1 U7.11
USBP1+: CN3.35 U16.AT7
USBP1-: CN3.36 U16.AR7
USBP2+: EL9.4 U16.AP8
USBP2+_R: EL9.3 ESD3.3 JP2.4
USBP2-: EL9.1 U16.AR8
USBP2-_R: EL9.2 ESD3.1 JP2.5
USBP4+: EL2.2 U16.AL15
USBP4+_L: EL2.1 J1.37
USBP4-: EL2.3 U16.AM15
USBP4-_L: EL2.4 J1.36
USBP5+: EL8.4 U16.AN13
USBP5+_L: CN4.3 EL8.3
USBP5-: EL8.1 U16.AM13
USBP5-_L: CN4.5 EL8.2
USBPLLMON_N: R148.1 U16.AN10
USBPLLMON_P: R140.1 U16.AM10
VCHGR_ACDET: PC69.1 PQ10.3 PR88.1 PR89.2 PU12.6
VCHGR_ACDRV: PR121.2 PU12.4
VCHGR_ACN: PC87.2 PC90.1 PR210.2P PU12.1
VCHGR_ACP: PC86.1 PC87.1 PR210.1P PU12.2
VCHGR_BST: PR116.1 PU12.17
VCHGR_CMSRC: PR105.2 PU12.3
VCHGR_DH: PQ28.4 PU12.18 TP47.1
VCHGR_DL: PQ29.4 PU12.15 TP46.1
VCHGR_LX: PC97.2 PC122.1 PL7.1 PQ28.1 PQ28.2 PQ28.3 PQ29.5 PQ29.6 PQ29.7 PQ29.8 PU12.19
VCHGR_SRN: PC82.1 PC83.2 PR211.2P PU12.12
VCHGR_SRP: PC83.1 PC85.1 PR211.1P PU12.13
VCHGR_VCC: PC96.2 PR119.2 PU12.20
VCORE_AGND: PC153.2 PC154.2 PC155.2 PC162.2 PR15.2 PR20.2 PR22.2 PR25.2 PR169.2 PR182.2 PR187.2 PU18.19 PU18.22 SJ1.2
VR_SVID_ALERT#: PR183.2 R284.2 R288.2 R289.2
VR_SVID_CLK: PR181.2 U16.N63
VR_SVID_DATA: PR189.2 R290.2 R293.2 U16.L63
WLAN_DX_WAKE#: R187.1 U4.N7
WLAN_ON/OFF#: Q18.1 R141.1 TP36.1 U16.AT5
WLAN_ON/OFF#_R: CN4.56 Q18.3 R216.1
WRST#: C39.1 D6.2 PQ1.3 R39.2 U4.L1
XCKPLL_MON_DN: TP16.1 U16.K21
XCKPLL_MON_DP: TP15.1 U16.M21
XDP_BPM0_R: TP76.1 U16.J60
XDP_BPM1_R: TP75.1 U16.H60
XDP_BPM2_R: TP65.1 U16.H61
XDP_BPM3_R: TP66.1 U16.H62
XDP_BPM4_R: TP8.1 U16.K59
XDP_BPM5_R: TP72.1 U16.H63
XDP_BPM6_R: TP81.1 U16.K60
XDP_BPM7_R: TP9.1 U16.J61
XDP_PRDY_N: TP73.1 U16.J62
XDP_PREQ_N: TP78.1 U16.K62
XDP_TCK0: R46.1 R405.1 U16.E60
XDP_TCK1: R112.2 TP109.1 U16.AE62
XDP_TDI: R133.2 TP110.1 U16.AD61
XDP_TDI_CPU: TP71.1 U16.F63
XDP_TDO_CPU: R45.1 TP70.1 U16.F62
XDP_TMS: R134.2 TP105.1 U16.AD62
XDP_TMS_CPU: TP69.1 U16.E61
XDP_TRST_CPU: R38.1 U16.AU62
XDP_TRST_CPU_N: R31.1 R38.2 U16.E59
XTAL24_DSP_IN: C129.2 R153.1 U10.2 Y1.3
XTAL24_DSP_OUT: C128.1 R153.2 U10.3 Y1.1
XTAL24_IN: C242.1 R260.1 U16.A25 Y2.3
XTAL24_OUT: C237.1 R260.2 U16.B25 Y2.1
N91758052: D20.1 Q33.3
N91759939: D21.1 Q34.3
N91761828: D22.1 Q35.3
N91763719: D23.1 Q20.3
N91886071: D19.1 Q31.3
N98656531: D20.2 R217.2
N98656602: D21.2 R229.2
N98656673: D22.2 R241.2
N98656744: D23.2 R243.2
N100531901: D19.2 R206.2
N122106153: R118.2 U16.AM7
N122106498: R69.1 U16.L5
N122114083: TP106.1 U16.AF2
N122114085: TP101.1 U16.AD2
N122114087: TP27.1 U16.AF4
N122114089: R35.1 U16.C26
N122114106: TP53.1 U16.B35
N122114113: TP62.1 U16.A35
N122118059: PD1.1 PD1.2 PD1.3 PR74.2 PU8.1
N122135977: PQ6.5 PR47.2 PR48.2 PR49.1
N122135991: PQ3.2 PQ4.2 PQ6.2 PQ6.3 PR37.2
N122136003: PQ3.3 PR36.1
N122136058: PC24.1 PQ9.4 PR33.2 PR36.2
N122136064: PQ4.3 PR33.1
N122136143: PQ6.6 PR39.2
N122146009: PC8.1 PU2.10
N122146015: PC7.1 PU2.12
N122148320: R346.1 U16.AV61 U17.2
N122232203: C53.1 R63.1 U16.K14 U16.K16
N122232279: C79.1 R90.1 U16.Y8
N122232606: C73.2 R82.2 U16.V8 U16.W9
N122232726: TP30.1 U16.AC20
N122232731: C106.1 C108.1 C109.1 R122.1 U16.AG10
N122232733: C99.1 U16.AE7
N122232990: R62.1 U16.J15
N122415913: PC19.1 PU5.10
N122415919: PC18.1 PU5.12
N122415954: EC54.1 J1.40 R308.1
N122416000: EC55.1 J1.39 R309.1
N122416321: R80.1 U5.1
N122428418: D12.2 U4.N3
N122428484: D15.1 U4.N4
N122428488: D14.1 U4.H4
N122428591: R99.1 U4.M3
N122428978: D1.1 U4.C12
N122429024: D4.1 U4.E13
N122431172: C82.1 U4.K5
N122431206: C45.2 L1.1 U4.E10
N122434299: PQ1.5 PQ1.6 PR26.2
N122439457: PC105.1 PU14.12
N122439463: PC107.1 PU14.10
N122446140: R297.2 R303.2 U15.7
N122446146: R304.2 R312.2 U15.3
N122446326: C247.1 R285.2 U15.8
N122446520: Q30.1 RTCR3.2 RTCR4.1
N122446579: D18.2 RTCR3.1
N122446658: Q30.2 RTCR1.2 RTCR2.1
N122449531: Q7.2 R160.2 R161.1
N122450119: PC118.1 PU16.10
N122450141: PC117.1 PU16.12
N122455005: CON1.51 R352.1
N122455420: PC50.1 PU9.12
N122455426: PC51.1 PU9.10
N122455442: D25.3 PR232.2
N122457781: R159.2 U11.1
N122457865: R172.2 U13.1
N122457919: C159.1 R176.1 R183.1 U12.5
N122457968: CN4.38 TP42.1
N122457970: CN4.40 TP44.1
N122457972: CN4.42 TP45.1
N122458088: R185.1 U14.5
N122458587: CN4.50 R205.1
N122463370: R169.2 R464.2 U10.17
N122463954: C196.2 Q19.2 R245.2 R246.1
N122464013: Q22.3 R246.2
N122468171: Q37.3 R23.1
N122495028: R104.2 U7.16
N122495042: C125.2 R125.2 U7.4
N122495050: R147.1 U7.7 U7.8
N122607796: C270.2 R381.1
N122610085: C271.2 R382.1
N122649084: C272.2 R383.1
N122814031: JBAT1.B5 PR141.1
N122814075: PQ15.1 PR149.1
N122814077: FL1.2 PC130.1 PQ15.3 PR137.1
N122814081: PQ13.3 PQ15.2 PR136.2
N122814089: PQ13.2 PR135.1 PR137.2
N122814123: PQ12.3 PR124.2 PR131.2 PR220.1
N122814144: JBAT1.B3 PR140.1
N122829049: PR58.1 PU7.3
N122829093: PR57.1 PU7.4
N122829099: PQ7.3 PR59.2
N122829101: PQ7.6 PR57.2
N122829103: PR59.1 PU7.2
N122829153: PC66.2 PD3.3
N122829159: PC45.1 PD2.1 PD3.2
N122829163: PC67.2 PD2.3
N122829414: PC93.2 PR109.1
N122829607: PC59.1 PR79.2
N122829826: PC92.2 PR108.1
N122829933: PC58.1 PR78.2
N122830133: PC191.1 PC192.1 PR204.2 PR207.1 PU20.3
N122830151: PQ31.2 PR208.2 PR219.2 PU20.4
N122832308: PC39.1 PC41.1 PR71.1 PR227.2 PR229.1
N122832375: PC72.1 PR91.2 PU10.2 PU10.20
N122832563: PC101.2 PR118.1
N122832615: PC81.1 PR104.2
N122833795: PC144.1 PR168.2 PU17.18
N122833803: PC2.2 PR8.1
N122833805: PC2.1 PC157.2 PL1.1 PU17.6 PU17.7 PU17.8 PU17.9
N122833835: PR171.1 PU17.5
N122833837: PC157.1 PR171.2
N122833953: PC152.1 PU17.21
N122834630: PC210.2 PR214.1 PR215.2 PU21.6
N122834634: PL8.2 PU21.1 PU21.2 PU21.3
N122834704: PC209.1 PR212.2 PR213.2 PU21.5
N122836621: PQ19.1 PR186.2
N122836623: PC158.2 PR176.2
N122836643: PC158.1 PQ19.7
N122836645: PQ19.6 PR176.1
N122836651: PR165.2 PU18.16
N122836744: PD9.2 PR188.1 PR226.1 PU18.3
N122836818: PR15.1 PR17.1 PU18.15
N122836933: PR187.1 PU18.4
N122837549: PC170.2 PR196.1
N122837792: PC170.1 PL3.1 PQ19.4
N122837844: PC163.1 PR24.1 PR190.1 PR191.2
N122837908: PC143.1 PR155.2
N122837932: PL3.3 PR192.1
N122837950: PR184.2 PR194.2
N122840555: PC114.1 PU15.10
N122840561: PC112.1 PU15.12
N122840674: PC12.1 PU3.10
N122840676: PC11.1 PU3.12
N122840820: PC177.1 PU19.6
N122840834: PC179.1 PR198.2 PR199.1 PU19.3
N122999755: PC141.2 PQ17.2 PR151.1 PR152.2
N122999770: PQ18.3 PR151.2
N123000271: PC5.1 PR18.2
N123081936: PR93.1 PR101.2 PU11.6
N123081950: PC61.1 PR84.2 PU11.4
N123206003: PQ18.2 R257.2 R264.2
N123302860: TP136.1 U16.AW36
N123302864: TP134.1 U16.AY36
N123302883: TP127.1 U16.AY42
N123302892: TP126.1 U16.AY43
N123302927: TP129.1 U16.AP32
N123305105: TP28.1 U16.AK38
N123305107: TP133.1 U16.AL38
N123305111: TP125.1 U16.AW49
N123305113: TP124.1 U16.AV50
N123305142: TP128.1 U16.AL32
N123329056: PC32.1 PR46.1 PU4.7 PU4.8
N123329129: PC25.1 PU4.6
N123329141: PR38.2 PR45.1 PU4.3
N123371162: R129.2 U7.9
N123381516: PU12.10 TP37.1
N123410461: Q14.3 Q15.2
N123410463: Q15.3 R208.1
N123704834: JP2.1 TP144.1
N123704844: JP2.3 TP143.1
N123705164: JP2.8 TP142.1
N123835164: PC123.1 PQ14.6 PR142.2
N123835172: PQ14.2 PQ16.3 PR147.1
N123835746: PC123.2 PQ14.5 PR130.1
N123837873: PD1.4 PQ14.3
N123838543: PC56.1 PC60.1 PR72.2 PR81.1 PU6.3
N123838812: PD1.6 PQ8.3
N123839469: PC33.1 PQ8.2 PR52.2
N123839474: PR51.1 PR52.1 PR218.2 PU6.4
N123840210: PD7.2 PQ16.1
N123840213: PQ16.2 PR150.2
N123896877: PR114.1 PR115.2 PU13.3 PU13.5
N123899946: R315.1 U16.AG4
N123901413: JP1.5 R388.2
N123966606: Q32.3 R385.2 R386.2
N123967231: R181.2 U13.12
N123967511: R162.2 U11.12
N123978329: J2.3 R391.2
N124020474: CN3.13 TP141.1
N124071044: R20.2 U4.E6
N124071159: D8.1 R76.2 R77.2
N124091307: D13.1 U4.L2
N124091332: D16.1 U4.M7
N124091386: CN4.20 R171.1
N124102893: CON1.6 R22.1
N124102895: CON1.28 R111.1
N124102897: CON1.48 R164.1
N124106909: R105.2 U7.15
N124425733: PQ12.2 PQ32.3 PR222.2
N124553844: Q38.3 Q39.2 R407.2
N124556156: Q39.3 R408.2
N124557432: Q40.3 Q41.2 R409.2
N124557495: Q41.3 R410.2
N124828984: CN4.9 R478.2
N124829261: CN4.11 R479.2
N124829264: CN4.13 R480.2
N124829267: CN4.15 R481.2
N124829270: CN4.17 R482.2
N124829273: CN4.19 R483.2
N124839218: Q42.5 Q42.6 R484.2
N124842117: Q43.5 Q43.6 R485.2
N124844057: Q44.5 Q44.6 R486.2
N126069126: PC89.1 PU13.10
N126069132: PC94.1 PU13.12
N126069331: PC102.1 PR117.1 PU13.13 PU13.14
N126069345: PC84.1 PR107.1 PU13.8 PU13.9
N127565517: PU8.2 PU8.3
N127565521: PC57.2 PR80.1 PU8.5 PU8.6
N127565531: PC57.1 PQ11.2 PU8.7
N127566558: PQ2.5 PQ2.6 PR31.2
N127566567: PC21.1 PQ2.3 PQ5.3 PR44.2
N127566661: PC110.2 PQ26.4 PQ27.4 PR121.1
N127566722: PQ30.4 PR100.2
N127566838: PC97.1 PD5.1 PR116.2
