# Allegro board dad13cmbag0-g-roger-165XL.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_A_DQ56: length 35.9
  IN4 w0.152: v2(50.21,44.15) 50.35,44.29 50.35,44.71 50.78,45.14 51.37,45.14 51.65,44.86 51.65,43.46 51.9,43.21 51.9,41.49 52.05,41.34 52.05,40.12 52.18,39.98 52.18,37.8 53.48,36.5 53.48,34.45 53.6,34.32 54.26,34.32 54.39,34.19 54.39,33.86 54.26,33.74 53.6,33.74 53.48,33.61 53.48,33.25 53.6,33.13 54.29,33.13 54.42,33 54.42,32.67 54.29,32.54 53.65,32.54 53.53,32.41 53.53,32.11 53.65,31.98 54.29,31.98 54.42,31.86 54.42,31.42 54.29,31.3 54.09,31.3 53.96,31.17 53.96,30.81 54.09,30.69 54.29,30.69 54.42,30.56 54.42,30.21 54.29,30.08 53.86,30.08 53.73,29.95 53.73,29.6 53.86,29.47 54.29,29.47 54.42,29.34 54.42,28.99 54.29,28.86 53.98,28.86 53.86,28.73 53.86,28.38 53.98,28.25 54.29,28.25 54.37,28.17 54.37,27.18 54.06,26.88 54.06,26.57 54.19,26.45 54.45,26.45 54.58,26.32 54.58,25.94 54.45,25.81 54.19,25.81 54.06,25.68 54.06,25.28 54.19,25.15 54.45,25.15 54.58,25.02 54.58,24.69 54.45,24.57 54.19,24.57 54.06,24.44 54.06,24.06 54.19,23.93 54.45,23.93 54.58,23.8 54.58,23.45 54.45,23.32 54.19,23.32 54.06,23.19 54.06,22.76 54.37,22.46 54.37,21.5 54.24,21.37 v2(53.54,21.37)
M_A_DQ57: length 35.2
  IN4 w0.152: v2(52.74,22.97) 52.74,23.43 52.87,23.56 53.55,23.56 53.68,23.68 53.68,24.01 53.55,24.13 53.35,24.13 53.22,24.26 53.22,24.62 53.35,24.74 53.55,24.74 53.68,24.87 53.68,25.25 53.55,25.38 53.35,25.38 53.22,25.51 53.22,25.89 53.35,26.01 53.55,26.01 53.68,26.14 53.68,26.47 53.55,26.6 53.35,26.6 53.22,26.73 53.22,27.16 53.35,27.28 53.86,27.28 53.98,27.41 53.98,27.74 53.86,27.87 53.48,27.87 53.35,28 53.35,29.6 53.22,29.72 52.24,29.72 52.11,29.85 52.11,31.02 52.24,31.14 52.87,31.14 52.99,31.27 52.99,31.7 52.87,31.83 52.24,31.83 52.11,31.96 52.11,32.39 52.24,32.52 52.79,32.52 52.92,32.64 52.92,32.95 52.79,33.08 52.24,33.08 52.11,33.2 52.11,33.56 52.24,33.68 52.79,33.68 52.92,33.81 52.92,34.17 52.79,34.29 52.24,34.29 52.11,34.42 52.11,34.73 52.24,34.85 52.82,34.85 52.94,34.98 52.94,35.26 52.82,35.39 52.24,35.39 52.11,35.51 52.11,35.89 52.24,36.02 52.84,36.02 52.97,36.15 52.97,36.47 52.84,36.6 52.21,36.6 51.37,37.45 51.37,38.82 50.94,39.25 50.94,41 51.14,41.2 51.14,41.69 50.84,41.99 50.84,42.83 49.84,43.82 49.84,45.05 v2(50.24,45.45)
M_A_DQ58: length 33.4
  IN4 w0.089: v2(48.26,44.15) 48.36,44.05 48.36,43.96 48.27,43.87 47.76,43.87 47.61,43.72 47.61,43.57 47.69,43.49 48.32,43.49 48.4,43.41 48.4,43.17 47.88,42.65 47.61,42.65 47.46,42.5 47.46,41.56 47.35,41.46 47.35,40.93 47.58,40.7 47.58,39.76
  IN4 w0.152: 47.58,39.76 47.58,38.69 50.16,36.12 50.16,35.47 49.97,35.29 49.97,34.57 50.16,34.39 50.16,33.92 49.97,33.74 49.97,29.38 49.62,29.03 49.62,28.27 49.49,28.15 48.87,28.15 48.74,28.02 48.74,27.72 48.87,27.59 49.49,27.59 49.62,27.46 49.62,27.2 49.49,27.07 48.66,27.07 48.22,27.51 48.04,27.51 47.89,27.36 47.89,26.57 48.02,26.45 48.25,26.45 48.38,26.32 48.38,26.01 48.25,25.89 47.97,25.89 47.84,25.76 47.84,25.43 47.97,25.3 48.25,25.3 48.38,25.18 48.38,24.79 48.25,24.67 47.91,24.67 47.79,24.54 47.79,24.21 47.91,24.08 48.25,24.08 48.38,23.96 48.38,23.68 48.25,23.55 47.97,23.55 47.43,23.02 47.43,22.79 47.68,22.54 47.92,22.54 48.35,22.97 v2(49.54,22.97)
M_A_DQ59: length 32.9
  IN4 w0.089: 47.33,40.02 47.33,40.7 47.18,40.85 47.18,41.63 47.25,41.71 47.25,43.74 47.99,44.48 47.99,45.16 v2(48.28,45.45)
  IN4 w0.152: 47.33,40.02 47.33,38.46 49.59,36.2 49.59,29.54 49.19,29.14 48.63,29.14 48.47,28.99 48.47,28.33 48.22,28.07 47.37,28.07 47.15,27.86 47.15,27.61 47.51,27.26 47.51,26.17 47.1,25.76 47.1,25.05 47.41,24.75 47.41,23.59 47.05,23.24 47.05,21.42 47.18,21.29 47.51,21.29 47.63,21.42 47.63,21.98 47.79,22.13 48.05,22.13 48.49,22.58 48.87,22.58 49.13,22.32 49.13,20.98 v2(49.54,20.57)
M_A_DQ60: length 35.1
  IN4 w0.089: 48.35,40.01 48.32,40.03 48.32,41.15 48.73,41.56 48.73,42.5 49.29,43.06 49.29,43.51 49.06,43.74 49.06,44.05 v2(49.16,44.15)
  IN4 w0.152: 48.35,40.01 48.42,39.93 49.03,39.93 49.13,39.83 49.13,39.43 48.93,39.22 48.93,38.66 49.77,37.83 50.43,37.83 50.61,37.65 50.61,37.13 51.35,36.39 51.35,29.09 51.48,28.96 51.62,28.96 51.75,28.83 51.75,28.5 51.62,28.38 50.94,28.38 50.81,28.25 50.81,27.87 50.94,27.74 51.6,27.74 51.72,27.61 51.72,27.31 51.6,27.18 50.94,27.18 50.81,27.06 50.81,26.75 50.94,26.62 51.7,26.62 51.83,26.5 51.83,26.19 51.7,26.06 51.33,26.06 51.2,25.94 51.2,25.56 51.33,25.43 51.65,25.43 51.78,25.3 51.78,25 51.65,24.87 51.06,24.87 50.94,24.74 50.94,24.36 51.06,24.24 51.22,24.24 51.35,24.11 51.35,22.6 51.5,22.44 51.83,22.44 51.98,22.29 51.98,21.99 51.83,21.83 51.25,21.83 51.12,21.71 51.12,21.46 50.77,21.1 50.77,20.75 51.01,20.5 51.4,20.5 52.27,21.37 v2(52.74,21.37)
M_A_DQ61: length 34.3
  IN4 w0.152: v2(53.54,22.97) 53.54,22.05 53.41,21.92 52.49,21.92 52.36,22.05 52.36,22.97 52.23,23.09 51.86,23.09 51.73,23.22 51.73,23.78 51.86,23.91 52.71,23.91 52.84,24.03 52.84,24.67 52.71,24.79 52.28,24.79 52.16,24.92 52.16,25.28 52.28,25.4 52.71,25.4 52.84,25.53 52.84,25.86 52.71,25.99 52.33,25.99 52.21,26.12 52.21,26.47 52.33,26.6 52.71,26.6 52.84,26.73 52.84,27 52.71,27.13 52.23,27.13 52.11,27.26 52.11,27.56 52.23,27.69 52.71,27.69 52.84,27.82 52.84,28.12 52.71,28.25 52.26,28.25 52.13,28.38 52.13,28.68 52.26,28.81 52.71,28.81 52.84,28.94 52.84,29.21 52.71,29.34 51.86,29.34 51.73,29.47 51.73,36.55 50.99,37.29 50.99,38.08 50.84,38.23 50.2,38.23 50.02,38.41 50.02,38.74 49.69,39.07 49.69,39.76 49.87,39.93 49.87,40.95 49.11,41.71 49.11,42.32 49.54,42.75 49.54,44.91 49.18,45.27 v2(49.18,45.45)
M_A_DQ62: length 31.7
  IN4 w0.089: v2(47.25,44.15) 47.25,44.63 47.15,44.73 47,44.73 46.59,44.33 46.59,44.15 46.87,43.87 46.87,43.75 46.46,43.33 46.46,41.67 46.64,41.48 46.8,41.48 46.92,41.36 46.92,40.85
  IN4 w0.152: v2(48.74,22.17) 48.32,21.75 48.32,21.49 47.69,20.86 46.8,20.86 46.67,20.99 46.67,23.68 47.03,24.03 47.03,24.59 46.72,24.9 46.72,25.92 47.13,26.32 47.13,27.1 46.77,27.46 46.77,28.01 47.21,28.45 47.97,28.45 48.09,28.58 48.09,29.29 48.32,29.52 49.03,29.52 49.21,29.7 49.21,36.22 46.92,38.51 46.92,38.82 47.05,38.94 47.05,39.3 46.92,39.43 46.92,39.76 47.08,39.91 47.08,40.37 46.92,40.52 46.92,40.85
M_A_DQ63: length 30.8
  IN4 w0.089: 46.67,40.85 46.67,41.13 46.28,41.52 46.28,44.45 v2(47.28,45.45)
  IN4 w0.152: 46.67,40.85 46.67,38.26 48.68,36.25 48.68,30.46 46.39,28.17 46.39,27.3 46.75,26.94 46.75,26.48 46.29,26.03 46.29,20.68 46.49,20.48 48.6,20.48 48.74,20.62 v2(48.74,21.37)
M_A_DQSN0: length 41.6
  IN3 w0.089: v2(41.01,45.76) 40.57,46.2 40.19,46.2 40.14,46.16 39.61,46.16 39.48,46.03 39.32,45.87 39.27,45.87 39.25,45.85
  IN3 w0.165: v2(19.21,18.17) 18.52,18.17 18.18,18.51 18.18,20.01 19.79,21.61 20.94,21.61 21.18,21.86 21.18,22.6 21.65,23.07 22.39,23.07 23.31,23.98 23.31,25.13 25.45,27.27 26.57,27.27 27.32,28.02 27.32,29.14 28.55,30.37 29.41,30.37 36.64,37.61 36.66,37.61 37.73,38.68 37.73,44.33 38.21,44.81 39.25,45.85
M_A_DQSN1: length 37.8
  IN4 w0.089: v2(40.36,43.33) 40.47,43.44 40.7,43.44 40.73,43.41 40.73,43.31 40.49,43.07 40.23,43.07 40.16,43.13 39.02,43.13 38.21,42.31 38.21,42.07 38.16,42.03 38.16,42.02
  IN4 w0.165: v2(16.01,22.17) 16.55,21.64 16.85,21.64 17.23,22.02 17.23,23.8 28.81,35.39 35.14,35.39 38.16,38.41 38.16,42.02
M_A_DQSN2: length 36.1
  IN3 w0.089: 40.73,38.76 40.75,38.77 40.75,38.78 40.78,38.82 40.78,39.35 40.65,39.48 40.65,40.31 40.73,40.39 40.73,42.5 42.25,44.02 42.48,44.02 v2(42.61,44.15)
  IN3 w0.165: v2(30.39,18.17) 29.47,18.17 29.11,18.54 29.11,19.62 30.91,21.43 31.95,21.43 32.22,21.16 32.52,21.16 32.73,21.36 32.73,21.68 32.39,22.01 32.39,22.43 32.82,22.86 33.27,22.86 33.71,22.42 33.99,22.42 34.18,22.62 34.18,22.9 33.75,23.33 33.75,23.79 40.73,30.77 40.73,35.66 40.75,35.67 40.75,38.75 40.73,38.76
M_A_DQSN3: length 32.3
  IN4 w0.089: 41.96,39.43 41.96,39.45 42,39.49 42,39.96 42.11,40.07 42.11,40.71 42.4,41 42.68,41 43.42,41.74 44.46,41.74 44.76,42.04 44.76,42.86 44.59,43.03 44.21,43.03 44,43.24 44,43.62 44.16,43.77 44.36,43.77 44.45,43.86 v2(44.45,44.15)
  IN4 w0.165: 41.96,39.43 41.96,39.14 41.45,38.63 41.45,36.03 34.49,29.07 33.83,29.07 27.99,23.23 27.99,22.04 27.73,21.78 27.33,21.78 27.19,21.92 v2(27.19,22.17)
M_A_DQSN4: length 31.8
  IN3 w0.089: v2(43.25,40.71) 43.25,40.56 43.51,40.3 43.51,39.65 43.37,39.51 43.37,38.88 43.54,38.71 44.05,38.71 44.28,38.49 44.34,38.49 44.36,38.47
  IN3 w0.165: 44.36,38.47 45.08,37.75 45.08,37.3 45.6,36.78 45.6,34.47 46.75,33.33 46.75,30.77 46.07,30.09 46.07,24.79 45.69,24.4 44.45,24.4 44.13,24.08 44.13,23.88 44.59,23.42 44.59,22.93 44.03,22.37 42.42,22.37 42.21,22.17 42.21,21.18 41.69,20.65 40.52,20.65 40.33,20.47 40.33,20 40.48,19.85 40.82,19.85 41.44,19.23 41.44,18.65 40.99,18.2 40.86,18.2 v2(40.8,18.15)
  BOTTOM w0.216: v2(40.8,18.15) 41.05,18.39 41.34,18.39 U20.G3
M_A_DQSN5: length 31.4
  IN4 w0.089: v2(45.68,40.71) 45.68,40.5 45.3,40.11 45.3,37.95 45.25,37.9 45.25,37.24 45.93,36.56 45.93,36.14 45.89,36.09 45.89,36.07
  IN4 w0.165: v2(38.36,22.17) 38.62,21.91 39.01,21.91 39.3,21.62 40.22,21.62 40.42,21.82 40.42,22.15 40.22,22.36 39.71,22.36 39.36,22.71 39.36,23.21 39.71,23.56 40.22,23.56 40.42,23.77 40.42,24.03 40.22,24.24 39.05,24.24 38.7,24.59 38.7,25.09 39.05,25.44 39.85,25.44 40.08,25.67 40.51,25.67 40.92,25.25 41.21,25.25 41.46,25.5 41.46,25.72 40.97,26.21 40.97,26.71 41.05,26.79 41.33,27.07 41.83,27.07 42.27,26.62 42.56,26.62 42.76,26.83 42.76,27.11 42.34,27.53 42.34,28.08 45.46,31.21 45.46,34.15 45.89,34.58 45.89,36.07
M_A_DQSN6: length 32
  IN3 w0.089: 51.43,40.07 51.4,40.07 51.36,40.11 51.09,40.11 50.84,40.37 50.84,42.7 51.22,43.08 51.75,43.08 52.51,43.84 52.51,44.59 52.3,44.8 v2(52.12,44.8)
  IN3 w0.165: v2(52.74,18.17) 52.52,18.39 51.41,18.39 51.01,18.79 51.01,19.88 51.89,20.75 51.89,24.19 52.37,24.68 52.37,28.87 53.08,29.58 53.08,30.18 52.41,30.85 52.41,31.67 53.08,32.34 53.08,32.69 52.37,33.4 52.37,36.77 51.57,37.58 51.57,39.06 51.71,39.21 51.71,39.95 51.59,40.07 51.43,40.07
M_A_DQSN7: length 32.7
  IN4 w0.089: 48.11,39.76 48.11,39.77 48.07,39.81 48.07,41.15 48.37,41.46 48.37,42.58 48.8,43 48.8,44.57 49.02,44.8 v2(49.16,44.8)
  IN4 w0.165: 48.11,39.76 48.11,39 50.89,36.22 50.89,28.99 50.35,28.45 50.35,26.67 50.02,26.34 49.24,26.34 49.11,26.22 49.11,25.72 49.24,25.6 50.1,25.6 50.38,25.31 50.38,24.67 50.1,24.39 49.24,24.39 49.11,24.26 49.11,23.83 49.24,23.7 50.6,23.7 50.89,23.42 50.89,22.76 50.61,22.48 50.1,22.48 49.87,22.25 49.87,21.69 50.04,21.52 50.53,21.52 50.64,21.63 50.64,21.78 50.51,21.92 v2(50.3,21.92)
  BOTTOM w0.216: U21.B7 49.9,21.81 50.19,21.81 v2(50.3,21.92)
M_A_DQSP0: length 41.5
  IN3 w0.089: 39.43,45.67 39.45,45.69 39.45,45.74 39.68,45.98 40.22,45.98 40.26,46.02 40.5,46.02 40.7,45.82 40.7,45.6 40.65,45.55 40.42,45.55 40.36,45.61 v2(40.36,45.76)
  IN3 w0.165: v2(19.21,18.97) 19.14,18.9 19.14,18.7 18.88,18.44 18.63,18.44 18.45,18.62 18.45,19.9 19.9,21.35 21.05,21.35 21.45,21.75 21.45,22.49 21.76,22.8 22.5,22.8 23.57,23.87 23.57,25.02 25.56,27 26.68,27 27.59,27.91 27.59,29.03 28.66,30.1 29.52,30.1 36.77,37.35 37.98,38.57 37.98,44.23 39.43,45.67
M_A_DQSP1: length 37.6
  IN4 w0.089: 38.43,42.02 38.43,42.03 38.38,42.07 38.38,42.24 39.1,42.96 40.09,42.96 40.16,42.89 40.56,42.89 41,43.33 v2(41.01,43.33)
  IN4 w0.165: 38.43,42.02 38.43,38.3 35.25,35.12 28.92,35.12 17.5,23.69 17.5,21.91 16.96,21.37 v2(16.01,21.37)
M_A_DQSP2: length 35.9
  IN3 w0.089: v2(42.61,43.5) 42.61,43.77 42.53,43.84 42.33,43.84 40.9,42.42 40.9,40.31 40.83,40.24 40.83,39.55 40.96,39.42 40.96,38.82 41,38.78 41,38.76
  IN3 w0.165: v2(30.39,18.97) 29.85,18.44 29.58,18.44 29.37,18.65 29.37,19.51 31.02,21.16 31.84,21.16 32.11,20.89 32.63,20.89 32.99,21.25 32.99,21.79 32.66,22.12 32.66,22.32 32.93,22.59 33.16,22.59 33.6,22.16 34.1,22.16 34.45,22.51 34.45,23.01 34.02,23.44 34.02,23.68 41,30.66 41,38.76
M_A_DQSP3: length 31.9
  IN4 w0.089: 42.22,39.43 42.22,39.45 42.18,39.49 42.18,39.89 42.29,40 42.29,40.64 42.48,40.82 42.76,40.82 43.49,41.56 44.53,41.56 44.94,41.97 44.94,42.93 44.66,43.21 44.28,43.21 44.18,43.31 44.18,43.54 44.23,43.59 44.36,43.59 v2(44.45,43.5)
  IN4 w0.165: 42.22,39.43 42.22,39.03 41.72,38.52 41.72,35.92 34.6,28.81 33.94,28.81 28.25,23.12 28.25,21.92 27.84,21.51 27.33,21.51 v2(27.19,21.37)
M_A_DQSP4: length 31.6
  IN3 w0.089: 44.2,38.26 44.16,38.3 44.16,38.36 43.98,38.54 43.46,38.54 43.19,38.8 43.19,39.73 43.06,39.86 43.06,39.99 43.14,40.06 v2(43.25,40.06)
  IN3 w0.165: v2(40.8,18.95) 40.64,18.95 40.5,18.8 40.5,18.57 40.6,18.47 40.88,18.47 41.17,18.76 41.17,19.12 40.7,19.59 40.37,19.59 40.07,19.89 40.07,20.58 40.41,20.92 41.58,20.92 41.95,21.29 41.95,22.28 42.3,22.64 43.92,22.64 44.32,23.04 44.32,23.31 43.86,23.77 43.86,24.19 44.34,24.67 45.58,24.67 45.81,24.9 45.81,30.21 46.48,30.88 46.48,33.22 45.34,34.36 45.34,36.67 44.82,37.19 44.82,37.64 44.2,38.26
  BOTTOM w0.216: U20.F3 41.32,18.72 41.02,18.72 v2(40.8,18.95)
M_A_DQSP5: length 31.1
  IN4 w0.089: v2(45.68,40.06) 45.47,39.85 45.47,37.88 45.43,37.83 45.43,37.31 46.11,36.63 46.11,36.14 46.16,36.09 46.16,36.07
  IN4 w0.165: 46.16,36.07 46.16,34.47 45.73,34.04 45.73,31.1 42.6,27.97 42.6,27.64 43.02,27.22 43.02,26.72 42.67,26.36 42.16,26.36 41.72,26.8 41.44,26.8 41.24,26.6 41.24,26.32 41.73,25.83 41.73,25.39 41.32,24.99 40.81,24.99 40.4,25.4 40.19,25.4 39.96,25.18 39.16,25.18 38.96,24.98 38.96,24.7 39.16,24.5 40.33,24.5 40.69,24.14 40.69,23.66 40.33,23.3 39.82,23.3 39.63,23.1 39.63,22.82 39.82,22.62 40.33,22.62 40.69,22.26 40.69,21.71 40.33,21.35 39.19,21.35 38.9,21.65 38.64,21.65 v2(38.36,21.37)
M_A_DQSP6: length 31.8
  IN3 w0.089: 51.43,40.33 51.4,40.33 51.36,40.29 51.17,40.29 51.01,40.44 51.01,42.63 51.29,42.91 51.82,42.91 52.68,43.76 52.68,44.66 52.82,44.8 v2(53.07,44.8)
  IN3 w0.165: v2(52.74,18.97) 52.43,18.66 51.52,18.66 51.28,18.9 51.28,19.77 52.16,20.64 52.16,24.08 52.64,24.57 52.64,28.76 53.34,29.47 53.34,30.29 52.68,30.96 52.68,31.56 53.34,32.23 53.34,32.8 52.64,33.51 52.64,36.88 51.83,37.69 51.83,38.95 51.98,39.1 51.98,40.06 51.71,40.33 51.43,40.33
M_A_DQSP7: length 32.3
  IN4 w0.089: 47.84,39.76 47.84,39.78 47.89,39.82 47.89,41.23 48.19,41.53 48.19,42.65 48.62,43.08 48.62,44.59 48.41,44.8 v2(48.26,44.8)
  IN4 w0.165: v2(50.3,21.12) 50.17,21.25 49.93,21.25 49.6,21.58 49.6,22.37 49.99,22.75 50.5,22.75 50.62,22.87 50.62,23.31 50.49,23.44 49.12,23.44 48.84,23.72 48.84,24.37 49.12,24.66 49.99,24.66 50.11,24.78 50.11,25.2 49.99,25.33 49.12,25.33 48.84,25.61 48.84,26.33 49.12,26.61 49.91,26.61 50.08,26.78 50.08,28.56 50.62,29.1 50.62,36.11 47.84,38.89 47.84,39.76
  BOTTOM w0.216: v2(50.3,21.12) 49.94,21.48 49.65,21.48 U21.C7
M_A_ODT: length 61.3
  TOP w0.076: R244.1 18.91,14.3 18.78,14.43 18.35,14.43 v6(18.32,14.41)
  IN2 w0.089: v6(40.65,14.53) 41.75,13.43 44.93,13.43 45.68,12.68 51.25,12.68 v6(53.94,15.37) ; v6(18.32,14.41) 18.35,14.43 18.78,14.43 21.68,11.54 22.16,11.54 24.51,9.19 30.64,9.19 v6(30.73,9.28)
  IN4 w0.089: v6(40.65,14.53) 38.03,14.53 37.55,14.05 36.66,14.05 31.89,9.28 v6(30.73,9.28)
  BOTTOM w0.076: U21.J1 U21.K1 54.34,15.77 v6(53.94,15.37) ; U20.J1 U20.K1 42.79,15.4 41.32,15.4 40.65,14.74 v6(40.65,14.53) ; v6(30.73,9.28) 31.14,9.28 32.5,10.63 32.5,15.36 32.08,15.77 U19.K1 U19.J1 ; U18.J1 U18.K1 20.81,15.73 20.47,15.4 19.01,15.4 18.68,15.07 18.68,14.76 v6(18.32,14.41)
M_A_RAS#: length 125.4
  TOP w0.089: R431.2 36.94,16.84 v9(36.18,17.61)
  IN1 w0.076: v5(46.7,18.01) 46.34,18.01 46.24,18.11 46.24,18.85 46.16,18.93 45.93,18.93 45.86,18.85 45.86,18.06 45.81,18.01 45.55,18.01 45.48,18.09 45.48,18.85 45.4,18.93 45.2,18.93 45.12,18.85 45.12,18.01 44.7,17.59 43.18,17.59 42.91,17.86 36.43,17.86 v9(36.18,17.61) 35.93,17.85 35.93,18.05 35.88,18.1 35.7,18.1 35.63,18.04 35.63,17.63 35.55,17.56 35.4,17.56 35.33,17.63 35.33,18.05 35.27,18.1 34.63,18.1 34.55,18.03 34.55,17.91 34.63,17.84 34.92,17.84 35.02,17.73 35.02,17.63 34.92,17.53 33.87,17.53 33.65,17.75 33.65,18.01 33.54,18.13 24.46,18.13 v5(24.34,18.01)
  IN2 w0.165: v9(36.18,17.61) 36.55,17.61 37.79,18.85 37.79,20.22 40.91,23.33 42.38,23.33 42.55,23.51 42.55,24.87 42.68,25 42.94,25 43.1,24.84 43.1,23.46 43.23,23.33 43.52,23.33 43.65,23.46 43.65,24.84 43.81,25 44.03,25 44.19,24.84 44.19,23.46 44.32,23.33 44.61,23.33 44.74,23.46 44.74,24.84 44.9,25 45.13,25 45.29,24.84 45.29,23.46 45.41,23.33 45.71,23.33 45.83,23.46 45.83,24.84 45.99,25 46.22,25 46.38,24.84 46.38,23.46 46.51,23.33 46.8,23.33 46.93,23.46 46.93,24.84 47.09,25 47.36,25 47.48,24.87 47.48,23.46 47.61,23.33 47.91,23.33 48.04,23.46 48.04,24.87 48.17,25 48.47,25 48.6,24.87 48.6,23.46 48.73,23.33 49.03,23.33 49.16,23.46 49.16,25.15 49.29,25.28 49.59,25.28 49.72,25.15 49.72,23.46 49.84,23.33 50.15,23.33 50.28,23.46 50.28,24.87 50.4,25 51.23,25 52.32,26.09 52.32,26.31 58.89,32.88 58.89,37.71 v5(57.75,38.84)
  IN4 w0.076: v2(30.39,16.57) 30.27,16.69 30.09,16.69 30.02,16.76 30.02,17.2 29.94,17.28 29.71,17.28 29.64,17.2 29.64,16.76 29.56,16.69 29.33,16.69 29.25,16.76 29.25,17.2 29.18,17.28 28.95,17.28 28.87,17.2 28.87,16.76 28.8,16.69 27.29,16.69 26.81,17.17 26.81,17.48 26.27,18.01 v5(24.34,18.01) 24.06,18.01 23.86,17.81 22.39,17.81 22.17,17.59 20.77,17.59 20.71,17.66 18.7,17.66 18.63,17.58 18.63,16.71 18.22,16.31 18.22,16.13 18.38,15.97 18.55,15.97 19.12,16.55 v2(19.21,16.55) ; v2(52.74,16.57) 53.45,16.57 53.6,16.42 53.6,16.18 53.45,16.03 52.84,16.03 52.19,16.69 49.65,16.69 49.16,17.17 49.16,17.48 48.63,18.01 v5(46.7,18.01) 45.22,18.01 45.02,17.81 44.74,17.81 44.52,17.59 43.13,17.59 43.06,17.66 41.06,17.66 40.98,17.58 40.98,16.71 40.48,16.21 40.48,16.03 40.63,15.87 40.8,15.87 41.47,16.55 v2(41.56,16.55)
  IN4 w0.165: v2(57.99,39.09) 57.99,39.08 v5(57.75,38.84)
M_A_WE#: length 116.3
  TOP w0.089: v9(35.6,15.3) v6(36.13,14.76) 36.59,14.3 36.66,14.3 R430.2
  IN1 w0.076: v5(24.32,15.88) 25.23,15.88 25.77,15.35 35.54,15.35 v9(35.6,15.3) 35.75,15.45 36.48,15.45 36.64,15.6 42.28,15.6 42.43,15.45 44.94,15.45 45.37,15.88 v5(46.67,15.88)
  IN2 w0.165: v9(35.6,15.3) 35.6,16.64 35.98,17.02 35.98,17.12 36.13,17.28 36.74,17.28 38.16,18.7 38.16,20.06 41.06,22.97 41.43,22.97 41.59,22.81 41.59,21.6 41.75,21.44 41.98,21.44 42.14,21.6 42.14,22.81 42.3,22.97 42.52,22.97 42.68,22.81 42.68,21.6 42.84,21.44 43.07,21.44 43.23,21.6 43.23,22.81 43.39,22.97 43.62,22.97 43.78,22.81 43.78,21.6 43.94,21.44 44.16,21.44 44.32,21.6 44.32,22.81 44.48,22.97 44.71,22.97 44.87,22.81 44.87,21.6 45.03,21.44 45.25,21.44 45.41,21.6 45.41,22.81 45.57,22.97 45.86,22.97 45.98,22.84 45.98,21.56 46.11,21.44 46.42,21.44 46.54,21.56 46.54,22.84 46.67,22.97 46.97,22.97 47.1,22.84 47.1,21.95 47.23,21.83 47.53,21.83 47.66,21.95 47.66,22.84 47.79,22.97 50.98,22.97 51.34,23.33 51.34,23.55 50.95,23.95 50.95,24.17 51.11,24.33 51.34,24.33 51.73,23.94 51.96,23.94 52.12,24.1 52.12,24.33 51.72,24.72 51.72,24.95 51.88,25.11 52.11,25.11 52.5,24.71 52.73,24.71 52.89,24.87 52.89,25.1 52.5,25.49 52.5,25.72 52.66,25.88 52.88,25.88 53.28,25.49 53.5,25.49 53.71,25.69 53.71,25.86 53.14,26.43 53.14,26.61 53.37,26.84 53.55,26.84 54.11,26.27 54.29,26.27 54.53,26.51 54.53,26.69 53.98,27.23 53.98,27.45 54.12,27.59 54.82,27.59 54.94,27.7 54.94,28.41 59.26,32.72 59.26,39.29 58.56,39.98 57.9,39.98 57.67,39.76 v5(57.67,39.39)
  IN4 w0.076: v2(41.56,14.97) 41.56,14.79 41.65,14.71 42.55,14.71 42.63,14.79 42.63,14.99 42.68,15.04 42.83,15.04 42.89,14.99 42.89,14.76 42.94,14.71 43.31,14.71 43.55,14.95 43.55,15.05 43.51,15.1 43.51,15.21 43.62,15.31 43.72,15.31 43.77,15.27 43.88,15.27 44.13,15.52 45.22,15.52 45.58,15.88 v5(46.67,15.88) 48.4,15.88 48.6,15.68 51.32,15.68 52.11,14.89 52.66,14.89 v2(52.74,14.97) ; v2(19.21,14.97) 19.21,14.79 19.29,14.71 20.2,14.71 20.28,14.79 20.28,14.99 20.33,15.04 20.48,15.04 20.53,14.99 20.53,14.76 20.58,14.71 20.96,14.71 21.2,14.95 21.2,15.05 21.16,15.1 21.16,15.21 21.26,15.31 21.37,15.31 21.42,15.27 21.52,15.27 21.78,15.52 22.87,15.52 23.23,15.88 v5(24.32,15.88) 26.04,15.88 26.25,15.68 28.97,15.68 29.75,14.89 30.31,14.89 v2(30.39,14.97)
  IN4 w0.165: v5(57.67,39.39) 57.99,39.71 v2(57.99,39.74)
M_B_A0: length 109.2
  TOP w0.089: R443.2 82.15,11.51 v7(80.71,12.96) 80.4,13.26 v9(80.17,13.26)
  IN1 w0.165: v9(80.17,13.26) 80.17,14.13 79.72,14.58 79.72,16.24 78.98,16.97 78.98,20.57 74.77,24.77 71.48,24.77 71,25.25 70.49,25.25 70.01,24.77 69.04,24.77 68.25,25.55 68.25,27.13 63.87,31.51 63.09,31.51 62.72,31.87 62.72,33.62 61.98,34.37 61.53,34.37 61.38,34.52 61.38,34.75 61.61,34.98 61.61,35.16 61.39,35.37 61.21,35.37 60.87,35.03 60.7,35.03 59.24,36.48 59.24,36.73 59.52,37.01 59.52,37.19 59.28,37.43 59.1,37.43 58.84,37.17 58.56,37.17 57.06,38.67 57.06,39.45 56.93,39.58 56.37,39.58 56.25,39.7 56.25,40.11 56.37,40.24 56.37,40.95 56.22,41.1 56.22,41.28 56.05,41.44 55.88,41.44 55.36,41.96 55.36,42.16 53.76,43.77 53.58,43.77 53.38,43.57 53.38,43.39 v5(54.21,42.56)
  IN2 w0.076: v5(90.79,14.36) 90.79,14.66 90.69,14.76 90.18,14.76 90.05,14.63 90.05,13.72 89.95,13.62 89.49,13.62 89.39,13.72 89.39,14.13 89.34,14.18 89.11,14.18 89.04,14.1 89.04,13.67 88.99,13.62 88.76,13.62 88.66,13.72 88.66,13.82 88.61,13.87 88.43,13.87 88.35,13.8 88.35,13.67 88.3,13.62 88.14,13.62 88.06,13.7 88.06,13.82 87.99,13.9 87.84,13.9 87.76,13.82 87.76,13.7 87.68,13.62 87.53,13.62 87.45,13.7 87.45,13.82 87.38,13.9 87.23,13.9 87.15,13.82 87.15,13.7 87.07,13.62 86.92,13.62 86.85,13.7 86.85,13.82 86.77,13.9 86.62,13.9 86.54,13.82 86.54,13.7 86.46,13.62 86.31,13.62 86.24,13.7 86.24,13.82 86.16,13.9 86.01,13.9 85.93,13.82 85.93,13.7 85.85,13.62 85.68,13.62 85.43,13.36 80.27,13.36 v9(80.17,13.26) 80.15,13.24 77.84,13.24 77.58,13.49 74.89,13.49 74.81,13.57 74.81,13.85 74.73,13.92 74.58,13.92 74.51,13.85 74.51,13.57 74.43,13.49 74.28,13.49 74.2,13.57 74.2,13.85 74.12,13.92 73.97,13.92 73.9,13.85 73.9,13.57 73.82,13.49 73.67,13.49 73.59,13.57 73.59,13.85 73.51,13.92 73.36,13.92 73.29,13.85 73.29,13.57 73.21,13.49 73.06,13.49 72.98,13.57 72.98,13.85 72.91,13.92 72.75,13.92 72.68,13.85 72.68,13.57 72.6,13.49 72.03,13.49 71.67,13.85 68.95,13.85 v5(68.44,14.36)
  IN4 w0.076: v2(96.56,13.37) 96.12,13.37 94.78,14.71 91.15,14.71 v5(90.79,14.36) 90.61,14.18 90.15,14.18 89.98,14 87.92,14 87.56,13.64 85.93,13.64 85.86,13.57 85.86,13.39 85.76,13.29 85.46,13.29 v2(85.38,13.37) ; v2(74.2,13.37) 73.76,13.37 72.43,14.71 68.79,14.71 v5(68.44,14.36) 68.26,14.18 67.8,14.18 67.62,14 65.57,14 65.21,13.64 63.58,13.64 63.51,13.57 63.51,13.39 63.41,13.29 63.11,13.29 v2(63.03,13.37)
  IN4 w0.165: v2(53.88,42.85) 53.92,42.85 v5(54.21,42.56)
M_B_A1: length 113.5
  TOP w0.089: v9(79.31,9.17) 79,9.48 v7(78.14,9.48) 77.38,9.48 76.62,10.24 75.53,10.24 R436.2
  IN1 w0.089: v5(54.18,41.9) 54.18,42.02 54.27,42.11 54.48,42.11 54.57,42.02 54.57,41.51 55.04,41.04 55.39,41.04
  IN1 w0.165: 55.39,41.04 55.42,41.04 55.59,40.87 55.59,39.62 61.2,34 61.82,34 62.35,33.47 62.35,31.72 63.06,31.01 63.85,31.01 67.89,26.98 67.89,25.22 68.79,24.31 73.37,24.31 73.57,24.11 73.57,23.4 73.7,23.27 74,23.27 74.13,23.4 74.13,24.26 74.25,24.39 74.57,24.39 74.7,24.26 74.7,23.43 74.9,23.23 75.78,23.23 78.67,20.34 78.67,16.74 79.36,16.06 79.36,14.36 79.82,13.9 79.82,11.82 80.45,11.18 80.45,9.5 80.12,9.17 v9(79.31,9.17)
  IN2 w0.076: v5(65.8,10.06) 66.18,9.68 67.58,9.68 68.08,9.17 v9(79.31,9.17) 80.02,9.17 80.07,9.12 86.95,9.12 87.26,9.43 90.33,9.43 90.41,9.5 90.41,9.86 90.33,9.94 v5(88.27,9.94)
  IN4 w0.076: v2(93.36,12.57) 93.35,12.58 93.02,12.58 92.95,12.5 92.95,12.37 93.05,12.27 93.15,12.27 93.23,12.2 93.23,12.07 93.15,11.99 93,11.99 92.95,11.94 92.95,11.61 91.48,10.14 88.48,10.14 v5(88.27,9.94) 87.26,9.94 86.45,10.75 85.58,10.75 85.05,11.28 83.93,11.28 82.64,12.57 v2(82.18,12.57) ; v2(59.83,12.57) 61.12,11.28 62.7,11.28 63.23,10.75 64.09,10.75 64.78,10.06 v5(65.8,10.06) 65.87,10.14 69.12,10.14 70.74,11.75 70.74,12.23 70.6,12.37 70.6,12.5 70.67,12.58 71,12.58 v2(71,12.57)
  IN4 w0.165: v2(53.88,42.19) v5(54.18,41.9)
M_B_A2: length 114
  TOP w0.089: v9(79.26,11.31) 79.72,10.85 v7(80.07,10.85) 80.58,10.34 82.14,10.34 R437.2
  IN1 w0.089: 55.2,38.94 55.05,38.94 54.8,39.19 54.8,40.87 54.28,41.39 54.11,41.39 53.76,41.75 53.76,42.17 v5(53.37,42.56)
  IN1 w0.165: v9(79.26,11.31) 79.59,10.98 79.77,10.98 79.89,11.1 79.89,11.28 79.51,11.66 79.51,13.76 79,14.27 79,15.85 78.37,16.49 78.37,19.98 75.49,22.86 73.24,22.86 73.11,22.99 73.11,23.78 72.98,23.91 67.75,23.91 67.52,24.14 67.52,26.82 67.39,26.95 67.04,26.95 66.91,26.82 66.91,25.33 66.79,25.2 66.41,25.2 66.28,25.33 66.28,27 65.49,27.8 65.49,28.03 65.76,28.31 65.76,28.54 65.53,28.77 65.29,28.77 65.02,28.5 64.78,28.5 64.55,28.73 64.55,28.97 64.83,29.24 64.83,29.47 64.59,29.71 64.36,29.71 64.08,29.43 63.85,29.43 63.62,29.67 63.62,29.9 63.89,30.17 63.89,30.41 63.66,30.64 63.42,30.64 63.15,30.37 62.92,30.37 61.68,31.6 61.68,32.59 61.99,32.9 61.99,33.3 61.66,33.63 61.01,33.63 55.7,38.94 55.2,38.94
  IN2 w0.076: v5(67.95,11.43) 68.34,11.43 68.67,11.76 69.07,11.76 69.68,11.16 76.64,11.16 76.74,11.05 79,11.05 v9(79.26,11.31) 79.41,11.31 79.79,10.93 86.45,10.93 86.93,11.41 90.28,11.41 v5(90.31,11.43)
  IN4 w0.076: v2(74.2,12.57) 74.16,12.53 73.11,12.53 72.37,13.26 69.76,13.26 68.95,12.45 68.95,12.09 68.29,11.43 v5(67.95,11.43) 67.8,11.59 65.01,11.59 64.55,12.04 62.62,12.04 62.47,11.89 62.21,11.89 62.14,11.97 62.14,12.25 62.24,12.35 v2(62.65,12.35) ; v2(96.56,12.57) 96.51,12.53 95.46,12.53 94.73,13.26 92.11,13.26 91.3,12.45 91.3,12.09 90.64,11.43 v5(90.31,11.43) 90.15,11.59 87.36,11.59 86.9,12.04 84.97,12.04 84.82,11.89 84.57,11.89 84.49,11.97 84.49,12.25 84.59,12.35 v2(85,12.35)
  IN4 w0.165: v2(53.07,42.85) v5(53.37,42.56)
  BOTTOM w0.076: v2(85,12.35) 85.16,12.35 U24.P3 ; v2(62.65,12.35) 62.8,12.35 U22.P3
M_B_A3: length 119.7
  TOP w0.089: R451.2 71.45,15.57 74.15,15.57 75.1,14.62 76.73,14.62 77.3,14.05 77.99,14.05 v7(78.62,13.42) 79.16,12.88 v9(79.18,12.88)
  IN1 w0.165: v5(53.37,41.9) 53.37,41.63 54.05,40.95 54.05,39.98 54.04,39.96 54.04,38.59 54.22,38.4 55.72,38.4 61.29,32.83 61.29,31.39 64.06,28.61 64.06,28.39 63.49,27.81 63.49,27.59 63.65,27.43 63.87,27.43 64.45,28 64.67,28 64.83,27.84 64.83,27.61 64.26,27.04 64.26,26.81 64.42,26.65 64.65,26.65 65.22,27.23 65.45,27.23 65.64,27.03 65.64,26.88 65.03,26.27 65.03,26.04 65.71,25.37 65.71,23.46 65.83,23.33 66.23,23.33 66.35,23.46 66.35,24.71 66.48,24.83 66.86,24.83 66.99,24.71 66.99,23.5 67.12,23.37 72.58,23.37 72.7,23.25 72.7,22.61 72.83,22.48 75.26,22.48 78.06,19.68 78.06,16.24 78.65,15.65 78.65,14.18 79.16,13.66 79.16,12.9 v9(79.18,12.88)
  IN2 w0.076: v5(68.18,13.8) 68.49,13.49 69.58,13.49 69.86,13.21 70.02,13.21 70.1,13.29 70.1,13.49 70.18,13.57 70.33,13.57 70.4,13.49 70.4,13.29 70.48,13.21 70.63,13.21 70.71,13.29 70.71,13.49 70.78,13.57 70.94,13.57 71.01,13.49 71.01,13.29 71.09,13.21 71.24,13.21 71.32,13.29 71.32,13.49 71.39,13.57 71.55,13.57 71.62,13.49 71.62,13.29 71.7,13.21 77.51,13.21 77.84,12.88 v9(79.18,12.88) 80.38,12.88 80.58,13.09 85.63,13.09 85.89,13.34 90.03,13.34 90.31,13.06 90.84,13.06 90.92,13.14 90.92,13.7 90.81,13.8 v5(90.54,13.8)
  IN4 w0.076: v2(86.18,13.37) 87.82,13.37 87.9,13.45 87.9,13.68 87.98,13.75 88.15,13.75 88.2,13.7 88.2,13.45 88.28,13.37 88.43,13.37 88.51,13.45 88.51,13.7 88.59,13.78 88.74,13.78 88.81,13.7 88.81,13.45 88.89,13.37 89.04,13.37 89.12,13.45 89.12,13.7 89.2,13.78 89.35,13.78 89.42,13.7 89.42,13.44 89.49,13.37 89.65,13.37 89.72,13.44 89.72,13.75 89.8,13.82 89.95,13.82 90.03,13.75 90.03,13.4 90.06,13.37 90.26,13.37 90.33,13.44 90.33,13.75 90.38,13.8 v5(90.54,13.8) 90.74,13.8 91.42,14.48 93.43,14.48 94.12,13.8 95.18,13.8 95.88,13.11 97.09,13.11 v2(97.36,13.37) ; v2(63.83,13.37) 65.47,13.37 65.55,13.45 65.55,13.68 65.62,13.75 65.8,13.75 65.85,13.7 65.85,13.45 65.93,13.37 66.08,13.37 66.16,13.45 66.16,13.7 66.23,13.78 66.39,13.78 66.46,13.7 66.46,13.45 66.54,13.37 66.69,13.37 66.77,13.45 66.77,13.7 66.84,13.78 67,13.78 67.07,13.7 67.07,13.44 67.14,13.37 67.3,13.37 67.37,13.44 67.37,13.75 67.45,13.82 67.6,13.82 67.68,13.75 67.68,13.4 67.71,13.37 67.91,13.37 67.98,13.44 67.98,13.75 68.03,13.8 v5(68.18,13.8) 68.39,13.8 69.07,14.48 71.08,14.48 71.76,13.8 72.83,13.8 73.52,13.11 74.74,13.11 v2(75,13.37)
  IN4 w0.165: v2(53.07,42.19) v5(53.37,41.9)
M_B_A4: length 119.9
  TOP w0.089: v9(79.84,9.73) 79.89,9.68 v7(80.58,9.68) 80.76,9.86 81.87,9.86 82.46,9.27 82.46,9.01 R450.2
  IN1 w0.165: v9(79.84,9.73) 79.69,9.58 79.46,9.58 79.36,9.68 79.36,10.66 78.72,11.3 78.72,12.38 78.47,12.63 78.47,13.38 77.94,13.91 77.94,15.19 77.43,15.7 77.43,19.03 76.39,20.07 75.78,20.07 75.46,20.39 75.46,21.03 74.81,21.67 71.93,21.67 71.07,22.53 65.29,22.53 64.91,22.92 64.91,25.1 64.78,25.23 64.45,25.23 64.32,25.1 64.32,24.44 64.2,24.31 63.87,24.31 63.74,24.44 63.74,26.18 61.44,28.48 61.44,28.7 62.09,29.36 62.09,29.54 61.89,29.74 61.71,29.74 61.1,29.14 60.92,29.14 60.69,29.37 60.69,29.55 61.32,30.18 61.32,30.31 60.36,31.27 60.36,32.72 58.73,34.35 54.73,34.35 53.27,35.81 53.27,39.65 52.81,40.12 52.63,40.12 52.28,40.47 52.28,41.06 52.02,41.32 52.02,42.07 51.88,42.22 51.71,42.22 v5(51.44,41.95)
  IN2 w0.076: v5(65.34,10.42) 66,10.42 66.46,9.96 74.92,9.96 75.14,9.73 v9(79.84,9.73) 79.97,9.73 80.07,9.83 80.07,9.96 80.15,10.04 80.29,10.04 80.36,9.96 80.36,9.94 80.44,9.86 80.59,9.86 80.67,9.94 80.67,9.96 80.74,10.04 80.9,10.04 80.97,9.96 80.97,9.94 81.05,9.86 81.2,9.86 81.28,9.94 81.28,9.96 81.35,10.04 81.51,10.04 81.58,9.96 81.58,9.94 81.66,9.86 81.81,9.86 81.89,9.94 81.89,9.96 81.96,10.04 82.07,10.04 82.15,9.96 82.15,9.76 82.22,9.68 82.38,9.68 82.45,9.76 82.45,9.99 82.53,10.06 82.68,10.06 82.76,9.99 82.76,9.76 82.83,9.68 82.98,9.68 83.06,9.76 83.06,9.99 83.14,10.06 83.29,10.06 83.37,9.99 83.37,9.76 83.44,9.68 83.59,9.68 83.67,9.76 83.67,9.99 83.75,10.06 83.9,10.06 83.98,9.99 83.98,9.76 84.05,9.68 84.2,9.68 84.28,9.76 84.28,9.99 84.36,10.06 84.51,10.06 84.59,9.99 84.59,9.76 84.66,9.68 84.81,9.68 84.89,9.76 84.89,9.99 84.97,10.06 85.12,10.06 85.19,9.99 85.19,9.76 85.27,9.68 85.42,9.68 85.5,9.76 85.5,9.99 85.58,10.06 85.73,10.06 85.8,9.99 85.8,9.76 85.88,9.68 86.03,9.68 86.11,9.76 86.11,9.96 86.19,10.04 86.34,10.04 86.4,9.99 86.4,9.73 86.45,9.68 86.65,9.68 86.7,9.73 86.7,10.01 86.73,10.04 86.95,10.04 87.03,10.11 87.03,10.27 87.12,10.36 87.25,10.36 87.31,10.29 87.31,10.04 87.36,9.99 87.56,9.99 87.61,10.04 87.61,10.34 v5(87.69,10.42)
  IN4 w0.076: v2(70.2,12.57) 70.03,12.57 69.9,12.44 69.9,12.34 69.97,12.26 70.24,12.26 70.32,12.18 70.32,12.03 70.24,11.96 69.97,11.96 69.9,11.88 69.9,11.32 69,10.42 v5(65.34,10.42) 64.83,10.42 64.22,11.03 63.36,11.03 62.8,11.59 61.22,11.59 59.95,12.86 59.31,12.86 v2(59.03,12.57) ; v2(92.56,12.57) 92.38,12.57 92.25,12.44 92.25,12.34 92.33,12.26 92.59,12.26 92.67,12.18 92.67,12.03 92.59,11.96 92.33,11.96 92.25,11.88 92.25,11.32 91.35,10.42 v5(87.69,10.42) 87.18,10.42 86.57,11.03 85.71,11.03 85.15,11.59 84.11,11.59 82.84,12.86 81.66,12.86 v2(81.38,12.57)
  IN4 w0.165: v5(51.44,41.95) 51.19,42.19 v2(51.14,42.19)
M_B_A5: length 123
  TOP w0.089: v9(79.18,11.71) 78.88,12.02 77.18,12.02 76.54,12.65 v7(76.16,12.65) 75.65,13.16 74.51,13.16 74.13,13.54 R454.2
  IN1 w0.165: v9(79.18,11.71) 79.16,11.74 79.16,12.41 78.83,12.74 78.83,13.56 78.29,14.09 78.29,15.4 77.73,15.96 77.73,19.38 75.05,22.06 72.49,22.06 72.34,22.22 72.34,22.81 72.18,22.97 65.68,22.97 65.34,23.31 65.34,25.21 62.98,27.58 62.98,27.82 63.56,28.41 63.56,28.59 63.35,28.8 63.17,28.8 62.49,28.12 62.32,28.12 62.1,28.34 62.1,28.52 62.78,29.19 62.78,29.37 60.92,31.23 60.92,32.68 56.75,36.85 53.83,36.85 53.71,36.98 53.71,37.29 53.83,37.42 54.44,37.42 54.57,37.55 54.57,37.83 54.44,37.95 53.78,37.95 53.65,38.08 53.65,39.65 53.22,40.08 53.22,40.86 53.33,40.96 53.33,41.14 52.93,41.54 52.93,42.21 52.33,42.8 51.69,42.8 v5(51.44,42.56)
  IN2 w0.076: v5(90.74,12.07) 90.46,11.79 90.17,11.79 90.09,11.87 90.09,12.55 90.01,12.63 89.86,12.63 89.79,12.55 89.79,11.87 89.71,11.79 89.56,11.79 89.48,11.87 89.48,12.55 89.41,12.63 89.25,12.63 89.18,12.55 89.18,11.87 89.1,11.79 88.95,11.79 88.87,11.87 88.87,12.27 88.8,12.35 88.64,12.35 88.57,12.27 88.57,11.87 88.49,11.79 86.85,11.79 86.4,11.33 80.1,11.33 79.72,11.71 v9(79.18,11.71) 78.93,11.71 78.8,11.59 78.8,11.38 78.72,11.31 78.6,11.31 78.52,11.38 78.52,11.66 78.47,11.71 78.3,11.71 78.22,11.64 78.22,11.38 78.15,11.31 77.99,11.31 77.92,11.38 77.92,11.64 77.84,11.71 77.69,11.71 77.61,11.64 77.61,11.38 77.54,11.31 77.38,11.31 77.31,11.38 77.31,11.64 77.23,11.71 77.08,11.71 77,11.64 77,11.38 76.93,11.31 76.77,11.31 76.72,11.36 76.72,11.46 76.64,11.54 76.54,11.54 76.46,11.61 76.46,11.66 76.41,11.71 76.26,11.71 76.21,11.66 76.21,11.64 76.11,11.54 75.98,11.54 75.91,11.61 75.91,11.64 75.83,11.71 75.68,11.71 75.6,11.64 75.6,11.61 75.52,11.54 75.37,11.54 75.3,11.61 75.3,11.64 75.22,11.71 75.07,11.71 74.99,11.64 74.99,11.61 74.81,11.43 74.71,11.43 74.63,11.51 74.63,11.56 74.55,11.64 74.4,11.64 74.32,11.56 74.32,11.51 74.25,11.43 74.1,11.43 74.02,11.51 74.02,11.56 73.94,11.64 73.79,11.64 73.72,11.56 73.72,11.51 73.64,11.43 73.49,11.43 73.41,11.51 73.41,11.56 73.33,11.64 73.18,11.64 73.11,11.56 73.11,11.51 73.03,11.43 72.88,11.43 72.8,11.51 72.8,11.56 72.72,11.64 72.57,11.64 72.5,11.56 72.5,11.51 72.42,11.43 72.27,11.43 72.19,11.51 72.19,11.56 72.11,11.64 71.96,11.64 71.89,11.56 71.89,11.51 71.81,11.43 71.66,11.43 71.58,11.51 71.58,11.56 71.51,11.64 71.35,11.64 71.28,11.56 71.28,11.51 71.2,11.43 71.05,11.43 70.97,11.51 70.97,11.56 70.9,11.64 70.74,11.64 70.67,11.56 70.67,11.51 70.59,11.43 70.44,11.43 70.36,11.51 70.36,11.56 70.29,11.64 70.13,11.64 70.06,11.56 70.06,11.51 69.98,11.43 69.83,11.43 69.2,12.07 v5(68.39,12.07)
  IN4 w0.076: v2(63.41,12.35) 64.78,12.35 65.29,11.84 65.84,11.84 65.92,11.92 65.92,12.04 66,12.12 66.15,12.12 66.23,12.04 66.23,11.92 66.3,11.84 66.45,11.84 66.53,11.92 66.53,12.04 66.61,12.12 66.76,12.12 66.83,12.04 66.83,11.92 66.91,11.84 67.06,11.84 67.14,11.92 67.14,12.04 67.22,12.12 67.37,12.12 67.44,12.04 67.44,11.92 67.52,11.84 67.68,11.84 67.73,11.89 67.73,11.99 67.83,12.09 68.36,12.09 v5(68.39,12.07) 68.39,12.27 69.59,13.48 72.64,13.48 73.28,12.84 74.73,12.84 v2(75,12.57) ; v2(85.76,12.35) 87.13,12.35 87.64,11.84 88.2,11.84 88.27,11.92 88.27,12.04 88.35,12.12 88.5,12.12 88.58,12.04 88.58,11.92 88.65,11.84 88.81,11.84 88.88,11.92 88.88,12.04 88.96,12.12 89.11,12.12 89.19,12.04 89.19,11.92 89.26,11.84 89.42,11.84 89.49,11.92 89.49,12.04 89.57,12.12 89.72,12.12 89.8,12.04 89.8,11.92 89.87,11.84 90.03,11.84 90.08,11.89 90.08,11.99 90.18,12.09 90.71,12.09 v5(90.74,12.07) 90.74,12.27 91.95,13.48 94.99,13.48 95.63,12.84 97.08,12.84 v2(97.36,12.57)
  IN4 w0.165: v5(51.44,42.56) 51.15,42.85 v2(51.14,42.85)
  BOTTOM w0.076: U24.P2 86.18,12.29 86.04,12.15 85.86,12.15 85.76,12.25 v2(85.76,12.35) ; v2(63.41,12.35) 63.41,12.25 63.51,12.15 63.69,12.15 63.83,12.29 U22.P2
M_B_A6: length 132.6
  TOP w0.089: R441.2 77.35,7.45 78.01,8.11 v7(78.11,8.11) 78.19,8.03 v9(78.19,7.5)
  IN1 w0.165: v5(50.42,39.43) 50.42,39.31 50.84,38.9 50.84,34.63 55.64,29.83 55.64,29.55 59.06,26.12 59.06,22.44 59.25,22.25 59.51,22.25 59.7,22.44 59.7,22.71 59.89,22.9 60.16,22.9 60.35,22.71 60.35,20.03 60.82,19.56 70.55,19.56 70.7,19.41 73.77,19.41 75.36,17.82 75.36,16.42 75.65,16.13 75.65,15.57 75.32,15.24 75.32,13.87 75.52,13.67 76.15,13.67 77.05,12.77 77.05,11.68 78.06,10.67 78.06,9.73 78.39,9.4 78.39,8.11 78.95,7.55 78.95,7.07 78.79,6.9 78.38,6.9 78.19,7.1 v9(78.19,7.5)
  IN2 w0.076: v5(88.73,7.7) 88.09,7.7 88.04,7.65 88.04,7.5 87.96,7.42 87.81,7.42 87.74,7.5 87.74,7.65 87.66,7.73 87.51,7.73 87.43,7.65 87.43,7.5 87.35,7.42 85.58,7.42 85.51,7.5 85.51,7.68 85.43,7.75 85.25,7.75 85.18,7.68 85.18,7.45 85.13,7.4 84.95,7.4 84.88,7.47 84.88,7.68 84.8,7.75 84.65,7.75 84.57,7.68 84.57,7.47 84.5,7.4 84.34,7.4 84.27,7.47 84.27,7.68 84.19,7.75 84.04,7.75 83.96,7.68 83.96,7.47 83.89,7.4 83.73,7.4 83.66,7.47 83.66,7.68 83.58,7.75 83.43,7.75 83.35,7.68 83.35,7.47 83.28,7.4 83.12,7.4 83.05,7.47 83.05,7.68 82.97,7.75 82.82,7.75 82.74,7.68 82.74,7.47 82.67,7.4 82.51,7.4 82.44,7.47 82.44,7.68 82.36,7.75 82.21,7.75 82.13,7.68 82.13,7.47 82.06,7.4 81.9,7.4 81.83,7.47 81.83,7.68 81.75,7.75 81.6,7.75 81.52,7.68 81.52,7.47 81.45,7.4 81.3,7.4 81.22,7.47 81.22,7.68 81.14,7.75 80.99,7.75 80.91,7.68 80.91,7.47 80.84,7.4 80.69,7.4 80.61,7.47 80.61,7.68 80.53,7.75 80.38,7.75 80.3,7.68 80.3,7.47 80.23,7.4 80.08,7.4 80,7.47 80,7.68 79.92,7.75 79.77,7.75 79.7,7.68 79.7,7.47 79.62,7.4 79.47,7.4 79.39,7.47 79.39,7.68 79.31,7.75 79.16,7.75 79.09,7.68 79.09,7.47 79.01,7.4 78.86,7.4 78.78,7.47 78.78,7.68 78.7,7.75 78.55,7.75 78.48,7.68 78.48,7.47 78.4,7.4 78.29,7.4 v9(78.19,7.5) 77.78,7.09 77.12,7.09 77.01,7.2 77.01,7.31 76.93,7.38 76.78,7.38 76.71,7.31 76.71,7.21 76.63,7.13 76.48,7.13 76.4,7.21 76.4,7.31 76.33,7.38 76.17,7.38 76.1,7.31 76.1,7.21 76.02,7.13 75.87,7.13 75.79,7.21 75.79,7.31 75.72,7.38 75.56,7.38 75.49,7.31 75.49,7.21 75.41,7.13 75.26,7.13 75.18,7.21 75.18,7.31 75.11,7.38 74.95,7.38 74.88,7.31 74.88,7.21 74.8,7.13 74.65,7.13 74.57,7.21 74.57,7.31 74.5,7.38 74.34,7.38 74.27,7.31 74.27,7.21 74.19,7.13 74.04,7.13 73.96,7.21 73.96,7.31 73.89,7.38 73.73,7.38 73.66,7.31 73.66,7.21 73.58,7.13 73.43,7.13 73.35,7.21 73.35,7.31 73.28,7.38 73.12,7.38 73.05,7.31 73.05,7.21 72.97,7.13 72.82,7.13 72.74,7.21 72.74,7.31 72.67,7.38 72.52,7.38 72.44,7.31 72.44,7.21 72.36,7.13 72.21,7.13 72.13,7.21 72.13,7.31 72.06,7.38 71.91,7.38 71.83,7.31 71.83,7.21 71.75,7.13 71.6,7.13 71.52,7.21 71.52,7.31 71.45,7.38 71.3,7.38 71.22,7.31 71.22,7.21 71.14,7.13 70.99,7.13 70.92,7.21 70.92,7.31 70.84,7.38 70.69,7.38 70.61,7.31 70.61,7.21 70.53,7.13 70.38,7.13 70.31,7.21 70.31,7.31 70.23,7.38 70.08,7.38 70,7.31 70,7.21 69.92,7.13 69.77,7.13 69.7,7.21 69.7,7.31 69.62,7.38 69.47,7.38 69.39,7.31 69.39,7.21 69.31,7.13 69.16,7.13 69.09,7.21 69.09,7.31 69.01,7.38 68.86,7.38 68.78,7.31 68.78,7.21 68.71,7.13 68.55,7.13 68.48,7.21 68.48,7.31 68.4,7.38 68.25,7.38 68.17,7.31 68.17,7.21 68.1,7.13 67.94,7.13 67.87,7.21 67.87,7.31 67.79,7.38 67.64,7.38 67.56,7.31 67.56,7.21 67.49,7.13 67.33,7.13 67.26,7.21 67.26,7.31 67.18,7.38 67.03,7.38 66.95,7.31 66.95,7.23 66.9,7.18 66.67,7.18 66.38,7.47 v5(66.38,7.7)
  IN4 w0.076: v2(71.89,10.93) 71.74,10.77 71.74,10.27 69.3,7.83 66.51,7.83 v5(66.38,7.7) 66.25,7.83 64.45,7.83 62.19,10.09 59.88,10.09 59.03,10.94 v2(59.03,11.77) ; v2(94.24,10.93) 94.09,10.77 94.09,10.27 91.53,7.7 v5(88.73,7.7) 88.61,7.83 86.8,7.83 84.54,10.09 82.23,10.09 81.38,10.94 v2(81.38,11.77)
  IN4 w0.165: v2(50.12,39.74) 50.12,39.74 v5(50.42,39.43)
  BOTTOM w0.076: v2(94.24,10.93) 94.27,10.95 94.27,11.84 93.94,12.17 92.95,12.17 U25.R8 ; v2(71.89,10.93) 71.92,10.95 71.92,11.84 71.59,12.17 70.6,12.17 U23.R8
M_B_A7: length 127.1
  TOP w0.089: R448.2 74.19,11.94 76.59,11.94 v7(77.33,11.21) 77.66,10.88 v9(77.66,10.62)
  IN1 w0.165: v5(50.42,38.61) 50.42,34.52 55.02,29.92 55.02,28.12 56.34,26.8 57.54,26.8 58.7,25.64 58.7,19.43 58.89,19.23 59.17,19.23 59.37,19.43 59.37,21.68 59.57,21.89 59.78,21.89 59.98,21.69 59.98,19.4 60.18,19.19 64.32,19.19 64.53,18.99 64.53,17.75 64.73,17.55 66.35,17.55 66.81,18.01 66.81,18.93 67.08,19.19 70.34,19.19 70.63,18.9 73.72,18.9 75.09,17.53 75.09,16.31 75.32,16.08 75.32,15.8 74.99,15.47 74.99,13.52 75.14,13.36 76.01,13.36 76.69,12.69 76.69,11.54 76.9,11.34 76.9,9.73 77.05,9.58 77.58,9.58 77.68,9.68 77.68,10.6 v9(77.66,10.62)
  IN2 w0.076: v5(68.92,11.41) 69.22,11.1 69.22,10.59 69.3,10.52 69.48,10.52 69.56,10.59 69.56,10.82 69.61,10.88 69.78,10.88 69.83,10.82 69.83,10.62 69.94,10.52 70.09,10.52 70.17,10.59 70.17,10.8 70.24,10.87 70.4,10.87 70.47,10.8 70.47,10.59 70.55,10.52 70.7,10.52 70.78,10.59 70.78,10.8 70.85,10.87 71.01,10.87 71.08,10.8 71.08,10.59 71.16,10.52 71.31,10.52 71.39,10.59 71.39,10.8 71.46,10.87 71.62,10.87 71.69,10.8 71.69,10.59 71.77,10.52 71.92,10.52 72,10.59 72,10.8 72.07,10.87 72.22,10.87 72.3,10.8 72.3,10.59 72.38,10.52 72.53,10.52 72.61,10.59 72.61,10.8 72.68,10.87 72.83,10.87 72.91,10.8 72.91,10.59 72.99,10.52 73.14,10.52 73.22,10.59 73.22,10.8 73.29,10.87 73.44,10.87 73.52,10.8 73.52,10.59 73.6,10.52 73.75,10.52 73.82,10.59 73.82,10.8 73.9,10.87 74.05,10.87 74.13,10.8 74.13,10.59 74.21,10.52 74.36,10.52 74.43,10.59 74.43,10.8 74.51,10.87 74.66,10.87 74.74,10.8 74.74,10.59 74.82,10.52 74.97,10.52 75.04,10.59 75.04,10.8 75.12,10.87 75.27,10.87 75.35,10.8 75.35,10.54 75.4,10.49 75.58,10.49 75.65,10.57 75.65,10.82 75.73,10.9 75.88,10.9 75.96,10.82 75.96,10.57 76.03,10.49 76.24,10.49 76.32,10.57 76.32,10.8 76.4,10.88 76.55,10.88 76.63,10.8 76.63,10.57 76.7,10.49 76.85,10.49 76.93,10.57 76.93,10.7 77.01,10.77 77.24,10.77 77.31,10.7 77.31,10.62 77.39,10.54 77.58,10.54 v9(77.66,10.62) 86.57,10.62 87.03,11.08 90.56,11.08 90.71,11.23 90.71,11.59 90.87,11.74 90.92,11.74 91.07,11.89 91.68,11.89 91.88,11.69 91.88,11.18 91.83,11.13 91.55,11.13 v5(91.27,11.41)
  IN4 w0.076: v2(86.18,11.77) 86.18,11.65 86.24,11.59 86.42,11.59 86.52,11.69 86.52,11.82 86.57,11.87 86.75,11.87 86.8,11.82 86.8,11.71 87.43,11.09 87.51,11.09 87.58,11.16 87.58,11.23 87.66,11.31 87.81,11.31 87.89,11.23 87.89,11.13 87.96,11.05 88.12,11.05 88.19,11.13 88.19,11.23 88.27,11.31 88.42,11.31 88.5,11.23 88.5,11.13 88.57,11.05 88.73,11.05 88.8,11.13 88.8,11.23 88.88,11.31 89.03,11.31 89.11,11.23 89.11,11.13 89.18,11.05 89.32,11.05 89.39,11.12 89.39,11.26 89.44,11.31 89.65,11.31 89.7,11.26 89.7,11.14 89.75,11.09 90.95,11.09 v5(91.27,11.41) 91.65,11.79 91.65,12.45 92.26,13.06 94.5,13.06 95.36,12.2 96.93,12.2 v2(97.36,11.77) ; v2(75,11.77) 74.58,12.2 73.01,12.2 72.15,13.06 69.91,13.06 69.3,12.45 69.3,11.79 v5(68.92,11.41) 68.6,11.09 67.4,11.09 67.35,11.14 67.35,11.26 67.29,11.31 67.09,11.31 67.04,11.26 67.04,11.12 66.97,11.05 66.83,11.05 66.75,11.13 66.75,11.23 66.68,11.31 66.53,11.31 66.45,11.23 66.45,11.13 66.37,11.05 66.22,11.05 66.15,11.13 66.15,11.23 66.07,11.31 65.92,11.31 65.84,11.23 65.84,11.13 65.76,11.05 65.61,11.05 65.54,11.13 65.54,11.23 65.46,11.31 65.31,11.31 65.23,11.23 65.23,11.16 65.15,11.09 65.08,11.09 64.45,11.71 64.45,11.82 64.4,11.87 64.22,11.87 64.17,11.82 64.17,11.69 64.07,11.59 63.89,11.59 63.83,11.65 v2(63.83,11.77)
  IN4 w0.165: v2(50.12,39.09) 50.42,38.78 v5(50.42,38.61)
M_B_A8: length 118.1
  TOP w0.089: R439.2 75.94,9.63 v7(76.51,9.63) 77.35,8.79 v9(77.58,8.79)
  IN1 w0.165: v9(77.58,8.79) 77.57,8.81 76.46,8.81 76.32,8.95 76.31,8.95 75.98,9.28 75.98,12.4 75.61,12.78 74.48,12.78 74.28,12.98 74.28,15.75 74.56,16.03 74.56,16.97 73.72,17.81 70.46,17.81 69.81,18.46 67.73,18.46 67.55,18.28 67.55,17.71 65.3,15.45 64.04,15.45 63.62,15.87 63.62,18.16 63.44,18.34 63.18,18.34 63,18.16 63,16.68 62.81,16.49 62.54,16.49 62.34,16.68 62.34,17.68 62.2,17.83 59.02,17.83 57.83,19.02 57.83,24.27 54.21,27.89 54.21,29.69 48.79,35.12 48.79,38.49 48.96,38.66 49.49,38.66 v5(49.62,38.54)
  IN2 w0.076: v5(65.01,9.02) 65.28,9.29 67.54,9.29 67.98,8.84 71.61,8.84 72.11,8.34 74.03,8.34 74.48,8.79 v9(77.58,8.79) 77.58,8.67 77.63,8.62 78.14,8.62 78.22,8.69 78.22,8.82 78.3,8.89 78.45,8.89 78.52,8.82 78.52,8.66 78.6,8.59 78.8,8.59 78.88,8.67 78.88,8.8 78.97,8.89 79.1,8.89 79.19,8.8 79.19,8.67 79.26,8.59 79.42,8.59 79.49,8.67 79.49,8.81 79.58,8.89 79.71,8.89 79.8,8.81 79.8,8.67 79.87,8.59 80.03,8.59 80.1,8.67 80.1,8.75 80.19,8.84 80.32,8.84 80.41,8.75 80.41,8.66 80.48,8.59 80.65,8.59 80.72,8.65 80.72,8.77 80.8,8.84 80.95,8.84 81.02,8.77 81.02,8.67 81.1,8.59 81.25,8.59 81.33,8.67 81.33,8.77 81.41,8.84 81.56,8.84 81.63,8.77 81.63,8.67 81.71,8.59 81.86,8.59 81.94,8.67 81.94,8.77 82.02,8.84 82.17,8.84 82.24,8.77 82.24,8.67 82.32,8.59 82.47,8.59 82.55,8.67 82.55,8.77 82.62,8.84 82.78,8.84 82.85,8.77 82.85,8.67 82.93,8.59 83.08,8.59 83.16,8.67 83.16,8.77 83.23,8.84 87.31,8.84 87.36,8.89 v5(87.36,9.02)
  IN4 w0.076: v2(59.65,11.37) 59.92,11.37 60.31,10.98 62.54,10.98 64.5,9.02 v5(65.01,9.02) 66.61,9.02 66.89,9.3 67.45,9.3 67.7,9.05 68.84,9.05 70.29,10.49 v2(70.29,10.52) ; v2(82,11.37) 82.08,11.28 83.5,11.28 83.8,10.98 84.9,10.98 86.85,9.02 v5(87.36,9.02) 88.96,9.02 89.24,9.3 89.8,9.3 90.05,9.05 91.2,9.05 92.64,10.49 v2(92.64,10.52)
  IN4 w0.165: v2(49.29,39.09) 49.29,38.86 v5(49.62,38.54)
  BOTTOM w0.076: v2(82,11.37) 81.77,11.37 U24.T8 ; U23.T8 70.29,10.88 v2(70.29,10.52) ; v2(92.64,10.52) 92.64,10.88 U25.T8 ; v2(59.65,11.37) 59.42,11.37 U22.T8
M_B_A9: length 125.3
  TOP w0.089: v9(78.57,10.19) 77.51,10.19 76.34,11.36 v7(76.06,11.36) 74.62,11.36 R449.2
  IN1 w0.165: v5(50.45,40.73) 50.45,40.46 50.96,39.95 51.44,39.95 51.76,39.63 51.76,38.88 51.95,38.69 51.95,35.21 56.3,30.87 59.12,30.87 59.26,30.73 59.26,30.41 59.13,30.28 57.11,30.28 56.98,30.15 56.98,29.82 57.11,29.7 59.13,29.7 59.26,29.57 59.26,29.1 61.49,26.86 61.49,20.86 61.62,20.73 61.96,20.73 62.09,20.86 62.09,24.26 62.21,24.39 62.51,24.39 62.63,24.26 62.63,20.83 62.76,20.71 71.1,20.71 71.49,20.32 74.02,20.32 75.44,18.9 75.68,18.9 76.34,18.24 76.34,17.92 75.89,17.48 75.89,16.67 76.31,16.25 76.31,15.04 76.87,14.48 76.87,13.47 77.4,12.93 77.4,12.07 78.09,11.38 78.09,11.05 78.47,10.67 78.47,10.29 v9(78.57,10.19)
  IN2 w0.076: v5(91.2,10.77) 91.17,10.77 90.97,10.57 90.74,10.57 90.66,10.65 90.66,10.7 90.56,10.8 90.37,10.8 90.29,10.72 90.29,10.65 90.22,10.57 90.06,10.57 89.99,10.65 89.99,10.72 89.91,10.8 89.76,10.8 89.68,10.72 89.68,10.65 89.61,10.57 89.45,10.57 89.38,10.65 89.38,10.72 89.3,10.8 89.15,10.8 89.07,10.72 89.07,10.65 89,10.57 88.84,10.57 88.77,10.65 88.77,10.72 88.69,10.8 88.54,10.8 88.46,10.72 88.46,10.65 88.39,10.57 88.23,10.57 88.16,10.65 88.16,10.72 88.08,10.8 87.16,10.8 86.7,10.34 78.72,10.34 v9(78.57,10.19) 78.55,10.22 78.15,10.22 78.07,10.14 78.07,10.09 77.99,10.01 77.84,10.01 77.76,10.09 77.76,10.14 77.69,10.22 77.54,10.22 77.46,10.14 77.46,10.09 77.38,10.01 77.23,10.01 77.15,10.09 77.15,10.14 77.08,10.22 76.93,10.22 76.85,10.14 76.85,10.09 76.77,10.01 76.62,10.01 76.55,10.09 76.55,10.14 76.47,10.22 76.32,10.22 76.24,10.14 76.24,10.09 76.16,10.01 76.01,10.01 75.94,10.09 75.94,10.14 75.86,10.22 75.71,10.22 75.63,10.14 75.63,10.09 75.55,10.01 75.4,10.01 75.33,10.09 75.33,10.14 75.25,10.22 75.14,10.22 75.12,10.24 67.5,10.24 67.32,10.42 67.32,10.62 67.47,10.77 v5(68.84,10.77)
  IN4 w0.076: v2(96.56,11.77) 95.1,11.77 94.03,12.84 92.37,12.84 91.96,12.43 91.96,11.54 v5(91.2,10.77) 90.24,10.77 90.16,10.7 89.94,10.7 89.86,10.77 89.63,10.77 89.55,10.7 89.33,10.7 89.25,10.77 89.02,10.77 88.94,10.7 88.72,10.7 88.64,10.77 88.41,10.77 88.34,10.7 88.11,10.7 88.03,10.77 87.23,10.77 86.7,11.31 85.94,11.31 85.84,11.41 85.84,11.74 85.76,11.82 85.42,11.82 v2(85.38,11.77) ; v2(63.03,11.77) 63.07,11.82 63.41,11.82 63.48,11.74 63.48,11.41 63.59,11.31 64.35,11.31 64.88,10.77 65.68,10.77 65.75,10.7 65.98,10.7 66.06,10.77 66.29,10.77 66.36,10.7 66.59,10.7 66.67,10.77 66.9,10.77 66.97,10.7 67.2,10.7 67.28,10.77 67.51,10.77 67.58,10.7 67.81,10.7 67.89,10.77 v5(68.84,10.77) 69.61,11.54 69.61,12.43 70.02,12.84 71.68,12.84 72.75,11.77 v2(74.2,11.77)
  IN4 w0.165: v5(50.45,40.73) 50.17,41.02 v2(50.17,41.04)
M_B_A10: length 121.2
  TOP w0.089: v9(80.07,15.02) 79.9,15.18 R445.2
  IN1 w0.165: v9(80.07,15.02) 80.15,15.09 80.15,16.36 79.79,16.72 79.79,17.23 80.15,17.58 80.15,17.78 80.74,18.38 80.74,20.52 74.91,26.35 74.1,26.35 73.97,26.48 73.97,27.36 73.85,27.49 73.57,27.49 73.44,27.36 73.44,26.48 73.31,26.35 73.05,26.35 72.91,26.5 72.91,28.12 72.78,28.25 72.48,28.25 72.35,28.12 72.35,26.25 72.22,26.12 71.92,26.12 71.8,26.25 71.8,28.14 71.67,28.26 70.14,28.26 69.7,27.82 69.32,27.82 64.5,32.64 64.5,33.1 64.93,33.53 64.93,33.71 64.78,33.86 64.12,33.86 63.99,33.99 63.99,34.29 64.12,34.42 64.95,34.42 65.07,34.55 65.07,34.9 64.95,35.03 63.84,35.03 63.59,34.78 63.36,34.78 62.98,35.16 62.98,35.46 63.1,35.59 63.87,35.59 64,35.72 64,35.99 63.87,36.11 63.26,36.11 63.07,36.3 63.07,36.54 63.38,36.86 63.38,37.04 63.21,37.21 62.95,37.21 62.63,36.89 62.51,36.89 62.26,37.15 62.26,37.35 62.52,37.62 62.52,37.82 62.38,37.97 62.17,37.97 61.65,37.44 61.53,37.44 61.33,37.65 61.33,37.85 61.82,38.34 61.82,38.52 61.68,38.67 61.47,38.67 61.21,38.4 61,38.4 60.85,38.55 60.85,38.76 61.12,39.02 61.12,39.22 60.97,39.37 60.77,39.37 60.43,39.03 60.27,39.03 60.13,39.17 60.13,39.3 60.39,39.55 60.39,39.81 60.24,39.95 60.05,39.95 59.57,39.47 59.35,39.47 59.2,39.62 59.2,39.8 59.65,40.24 59.65,40.5 59.5,40.64 59.29,40.64 58.95,40.3 58.72,40.3 58.58,40.45 58.58,40.65 58.84,40.92 58.84,41.1 58.67,41.27 58.49,41.27 58.23,41 58.02,41 57.31,41.71 57.31,42.7 56.35,43.67 56.35,44.15 56.4,44.2 56.4,44.73 56.27,44.86 55.97,44.86 55.84,44.99 55.84,45.24 55.97,45.37 56.59,45.37 56.72,45.24 v5(56.72,45.15)
  IN2 w0.076: v5(88.4,15.07) 88.4,14.89 88.3,14.79 88.1,14.79 88.05,14.84 85.18,14.84 85.08,14.94 85.08,15.14 85,15.22 84.77,15.22 84.7,15.14 84.7,15.09 84.62,15.02 84.43,15.02 84.35,15.09 84.35,15.14 84.27,15.22 84.12,15.22 84.05,15.14 84.05,14.71 83.97,14.63 83.82,14.63 83.74,14.71 83.74,15.14 83.66,15.22 83.51,15.22 83.44,15.14 83.44,14.71 83.36,14.63 83.21,14.63 83.13,14.71 83.13,15.14 83.06,15.22 82.9,15.22 82.83,15.14 82.83,14.71 82.75,14.63 82.6,14.63 82.52,14.71 82.52,15.14 82.45,15.22 82.29,15.22 82.22,15.14 82.22,14.76 82.09,14.63 81.81,14.63 81.68,14.76 81.68,15 81.54,15.14 80.58,15.14 80.48,15.04 80.48,14.4 80.38,14.3 80.16,14.3 80.07,14.4 v9(80.07,15.02) 69.33,15.02 68.82,15.52 68.06,15.52 67.6,15.07 v5(66.05,15.07)
  IN4 w0.076: v2(82.18,14.97) 82.2,14.97 82.23,14.94 84.85,14.94 85.33,14.46 87.26,14.46 87.87,15.07 v5(88.4,15.07) 88.4,15.24 88.48,15.32 89.32,15.32 89.49,15.5 90.71,15.5 90.81,15.4 v2(93.74,15.4) ; v2(71.38,15.4) 70.16,15.4 70.06,15.5 67.14,15.5 66.96,15.32 66.13,15.32 66.05,15.24 v5(66.05,15.07) 65.52,15.07 64.91,14.46 62.98,14.46 62.49,14.94 59.88,14.94 59.85,14.97 v2(59.83,14.97)
  IN4 w0.165: v5(56.72,45.15) 56.43,45.43 v2(56.43,45.45)
  BOTTOM w0.102: U23.L7 71,15.02 v2(71.38,15.4)
  BOTTOM w0.229: U25.L7 v2(93.74,15.4)
M_B_A11: length 123.5
  TOP w0.089: v9(77.48,8.03) 77.15,8.36 v7(76.36,8.36) 75.69,8.36 R440.2
  IN1 w0.165: v5(49.49,40.11) 49.72,40.11 50.02,39.81 50.02,34.4 54.58,29.85 54.58,28.04 56.3,26.32 57.41,26.32 58.19,25.54 58.19,19.18 58.54,18.83 63.78,18.83 63.99,18.62 63.99,16.03 64.19,15.82 65.14,15.82 67.18,17.86 67.18,18.43 67.57,18.83 69.96,18.83 70.49,18.29 73.75,18.29 74.83,17.21 74.83,15.79 74.69,15.65 74.69,13.24 74.84,13.09 75.74,13.09 76.29,12.54 76.29,11.38 76.5,11.17 76.5,9.29 76.62,9.17 77.73,9.17 77.99,8.92 77.99,7.83 77.71,7.55 77.71,7.12 77.55,6.95 76.82,6.95 76.62,7.16 76.62,7.73 76.82,7.93 77.38,7.93 v9(77.48,8.03)
  IN2 w0.076: v5(65.69,8.26) 66.33,8.26 66.81,7.78 77.23,7.78 v9(77.48,8.03) 85.6,8.03 85.68,7.95 85.68,7.9 85.76,7.83 85.91,7.83 85.98,7.9 85.98,7.95 86.06,8.03 86.21,8.03 86.29,7.95 86.29,7.9 86.36,7.83 86.52,7.83 86.59,7.9 86.59,7.95 86.67,8.03 86.82,8.03 86.9,7.95 86.9,7.9 86.97,7.83 87.13,7.83 87.2,7.9 87.2,7.95 87.28,8.03 87.41,8.03 87.77,8.39 87.92,8.39 v5(88.05,8.26)
  IN4 w0.076: v2(82.18,11.77) 82.01,11.77 81.73,11.5 81.73,10.99 82.36,10.37 84.67,10.37 86.78,8.26 v5(88.05,8.26) 88.17,8.13 91.55,8.13 93.81,10.39 v2(93.81,10.93) ; v2(71.46,10.93) 71.46,10.39 69.2,8.13 65.82,8.13 v5(65.69,8.26) 64.42,8.26 62.32,10.37 60,10.37 59.38,10.99 59.38,11.5 59.66,11.77 v2(59.83,11.77)
  IN4 w0.165: v2(49.29,40.39) 49.29,40.31 v5(49.49,40.11)
  BOTTOM w0.076: U23.R7 71.46,11.31 v2(71.46,10.93) ; U25.R7 93.81,11.31 v2(93.81,10.93)
