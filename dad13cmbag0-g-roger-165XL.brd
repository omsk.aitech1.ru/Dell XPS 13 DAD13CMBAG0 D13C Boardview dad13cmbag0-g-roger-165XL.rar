# Allegro board dad13cmbag0-g-roger-165XL.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
N124091332: length 7.5
  TOP w0.127: U4.M7 v4(138.09,54.48) ; v6(141.92,50.4) 141.51,49.99 D16.1 140.42,50.75 140.05,51.12 139.52,51.12 139.2,51.44 v4(139.23,51.44)
  IN1 w0.089: v4(138.09,54.48) 138.31,54.26 138.31,53.1 138.78,52.63 138.78,52.24 139.23,51.8 v4(139.23,51.44)
N124091386: length 4.4
  TOP w0.127: R171.1 178.95,33.23 v7(178.9,33.28) 178.9,33.86 v6(179.03,33.99)
  BOTTOM w0.127: CN4.20 179.23,32.65 179.03,32.85 v6(179.03,33.99)
N124102893: length 7.4
  TOP w0.127: v6(157.13,62.39) 157.01,62.51 v7(157.01,63.12) 157.08,63.2 R22.1
  BOTTOM w0.127: v6(157.13,62.39) 157.16,62.36 157.16,58.91 157.62,58.45 CON1.6
N124102895: length 4
  TOP w0.127: R111.1 156.59,47.16 v6(156.32,46.89) 156.32,46.66 v6(156.65,46.33)
  BOTTOM w0.127: CON1.28 156.77,46.45 v6(156.65,46.33)
N124102897: length 4.7
  TOP w0.127: R164.1 156.96,36.86 v6(157.19,37.09) 157.9,37.09 v7(157.92,37.06)
  BOTTOM w0.127: CON1.48 157.76,38.45 157.19,37.88 v6(157.19,37.09)
N124106909: length 1.8
  TOP w0.127: U7.15 199.56,47.9 R105.2
N124425733: length 5.9
  TOP w0.127: v7(6.18,17.99) PR222.2 6.66,16.98 6.79,16.84 PQ32.3 7.6,17.38 8.47,18.24 9.05,18.24 9.33,18.52 PQ12.2
N124553844: length 2.1
  TOP w0.127: v7(23.23,47.15) 23.28,47.2 Q38.3
N124556156: length 2.9
  TOP w0.127: v7(27.44,49.69) 27.34,49.59 R408.2
  TOP w0.508: Q39.3 28.1,47.32 27.34,48.08 R408.2
N124557432:
  vias: v7(114.49,16.82)
N124557495: length 1.1
  TOP w0.127: v7(117.38,22.97) 117.38,21.93 R410.2
N124828984: length 7
  BOTTOM w0.127: CN4.9 173.84,35.4 174,35.56 174,36.17 175.24,37.41 175.24,37.84 175.24,37.84 175.24,39.16 175.23,39.17 175.23,39.32 174.33,40.23 R478.2
N124829261: length 7.5
  BOTTOM w0.127: R479.2 175.35,40.15 175.62,39.88 175.62,37.23 174.38,36 174.38,35.29 174,34.9 CN4.11
N124829264: length 8.2
  BOTTOM w0.127: R480.2 176.36,39.99 176,39.63 176,37.05 174.76,35.82 174.76,35.11 174.05,34.4 CN4.13
N124829267: length 9.2
  BOTTOM w0.127: R481.2 176.38,39.58 176.38,36.85 175.14,35.62 175.14,34.93 174.11,33.9 CN4.15
N124829270: length 10.1
  BOTTOM w0.127: CN4.17 174.2,33.4 175.52,34.73 175.52,35.39 176.76,36.62 176.76,38.95 R482.2
N124829273: length 11.3
  BOTTOM w0.127: R483.2 178.24,39.41 177.85,39.41 177.14,38.7 177.14,36.34 175.93,35.13 175.93,34.57 174.26,32.9 CN4.19
N124839218: length 4.5
  TOP w0.127: R484.2 173,24.07 173.2,24.28 173.2,24.96 ; 173.2,24.96 173.06,25.1 173.06,25.35 173.31,25.61 Q42.5 ; 173.2,24.96 Q42.6
N124842117: length 3.5
  TOP w0.127: Q43.5 171.65,25.86 R485.2 171.26,26.51 Q43.6
N124844057: length 3.8
  TOP w0.127: 171.03,28.16 171.02,28.15 Q44.5 ; 171.03,28.16 171.03,27.76 R486.2 ; 171.03,28.16 171.03,28.66 170.89,28.8 Q44.6
N126069126: length 3.9
  TOP w0.127: v7(92.92,30.56) 92.92,30.44 PC89.1 93.69,29.42 94.14,28.97 94.14,28.6 94.5,28.25 94.83,28.25 94.94,28.14 PU13.10
N126069132: length 4.3
  TOP w0.127: PU13.12 94.8,27.34 94.35,27.79 94.35,28 PC94.1 93.16,29.19 v7(91.91,29.19)
N126069331:
  vias: v7(93.94,25.76)
N126069345: length 1.3
  TOP w0.127: PC84.1 92.92,31.82 v7(92.92,31.83)
N127565517: length 1.7
  TOP w0.305: PU8.2 132.59,39.07 132.71,38.94 132.71,38.71 132.56,38.57 PU8.3
N127565521:
  vias: v6(136.48,37.62)
N127565531: length 7.1
  TOP w0.254: PQ11.2 137.27,37.14 v6(137.75,37.62) 138.06,37.93 138.06,39.65 137.8,39.91 137.11,39.91 PC57.1 136.14,39.33 135.87,39.07 PU8.7
N127566558: length 4.5
  TOP w0.127: PR31.2 146.8,51.29 v7(146.82,51.31)
  TOP w0.254: PQ2.5 146.14,49.94 146.27,50.07 146.56,50.07 PR31.2 146.51,50.59 PQ2.6
N127566567:
  vias: v6(142.63,48.52)
N127566661: length 5.3
  TOP w0.508: PR121.1 PC110.2 122.04,20.16 v6(122.41,20.53)
  IN3 w0.508: v6(122.46,23.86) 122.41,23.8 v6(122.41,20.53)
N127566722: length 20.3
  TOP w0.254: v6(124.24,32.72) 123.9,33.06 PR100.2
  IN3 w0.254: v6(119.01,15.35) 119.01,25.46 124.24,30.69 v6(124.24,32.72)
N127566838:
  vias: v7(127.64,23.32)
N127566860:
  vias: v6(123.56,16.03)
N127567004:
  vias: v7(126.83,24.46)
N127567118: length 3.7
  TOP w0.127: PR132.1 128.51,14.23 127.85,13.57 v7(127.7,13.57)
  TOP w0.508: PC122.2 129.67,14.99 PR132.1
N127567146: length 2.2
  TOP w0.127: PR100.1 125.46,33.35 v6(125.64,33.18) 125.64,33.02 125.98,32.68 PU12.11
N127567165:
  vias: v7(129.75,23.7)

## Copper pours and planes (outline as drawn)
+0.675V_DDR_VTT on TOP (solid shape): 123.48,35.16 123.53,35.16 123.66,35.03 123.66,34.24 123.53,34.12 123.53,33.61 123.51,33.56 123.51,33.5 123.51,33.2 123.51,33.15 123.53,33.1 123.53,31.96 123.28,31.7 122.39,31.7 122.01,32.08 122.01,33.59 122.01,33.6 122.03,33.74 122.01,33.87 122.01,33.88 122.01,34.61 122.56,35.16 123.47,35.16
+0.675V_DDR_VTT on TOP (solid shape): outline of 3895 points within 24.09,6.57 96.2,20.93
+1.2V_SWR on TOP (solid shape): 105.37,17.81 105.37,16.34 104.99,15.96 102.45,15.96 102.22,16.18 102.22,17.23 102.52,17.53 103.51,17.53 104.43,18.44 104.73,18.44
+1.2V_SWR on TOP (solid shape): 112.51,32.12 112.51,30.71 112.44,30.64 110.17,30.64 110.05,30.76 110.05,32.51 112.12,32.51
+1.2V_SWR on TOP (solid shape): 104.34,31.96 104.34,30.39 104.19,30.28 104.09,30.12 104.09,30.1 103.6,29.61 102.88,29.61 102.8,29.69 102.8,30.03 102.52,30.31 101.58,30.31 101.42,30.47 101.42,31.14 101.57,31.3 102.65,31.3 103.34,31.98 104.33,31.98
+1.2V_SWR on TOP (solid shape): 99.29,40.28 99.29,37.76 100.04,37.01 103.84,37.01 103.84,36.71 102.27,36.71 101.99,36.43 101.77,36.43 101.76,36.43 101.61,36.43 101.53,36.5 99.83,36.5 99.76,36.58 98.79,36.58 98.69,36.68 98.69,37.09 98,37.77 97.11,37.77 97.01,37.88 97.01,39.53 97.83,40.34 99.22,40.34
+1.2V_SWR on TOP (solid shape): 114.16,40.87 114.16,40.21 113.6,39.65 113.6,39.04 113.57,39.02 112.81,39.02 112.79,39.04 112.79,39.88 112.61,40.06 111.59,40.06 111.54,40.01 111.54,39.41 111.01,38.88 111.01,38.43 110.8,38.23 109.56,38.23 109.54,38.25 109.54,39.2 110.11,39.2 110.87,39.96 110.87,40.64 111.05,40.82 111.06,40.82 111.16,40.92 114.11,40.92
+1.2V_SWR on IN4 (solid shape): 111.38,32.35 111.38,31.67 111.04,31.33 109.4,31.33 109.4,31.34 105.61,31.34 103.47,29.2 103.47,23.55 103.64,23.38 103.64,23.36 103.77,23.09 104.04,22.97 104.06,22.97 105.69,21.34 105.69,16.27 105.5,16.08 104.86,16.08 104.61,16.34 104.61,20.83 102.37,23.07 102.37,29.74 105.06,32.43 111.3,32.43
+1.2V_SWR_L on TOP (solid shape): 101.91,41.25 101.91,39.4 103.21,38.11 103.75,38.11 103.84,38.02 103.84,37.71 102.67,37.71 102.07,38.31 100.49,38.31 100.47,38.33 100.47,40.37 101.48,41.38 101.79,41.38
+1.05V_RUN on TOP (solid shape): 53.3,67.44 53.3,66.65 53.05,66.4 51.04,66.4 50.84,66.6 50.84,67.57 50.89,67.62 53.12,67.62
+1.05V_RUN on TOP (solid shape): 73.37,57.1 73.37,56.47 73.24,56.34 72.86,56.34 72.6,56.09 72.6,55.58 72.48,55.45 71.33,55.45 71.21,55.58 71.21,56.47 71.33,56.6 71.71,56.6 72.35,57.23 73.24,57.23
+1.5V_RUN on TOP (solid shape): 205.11,34.6 205.11,33.61 204.94,33.43 198.54,33.43 197.77,34.19 197.52,34.19 197.34,34.02 197.34,32.92 197.32,32.9 196.86,32.9 196.83,32.92 196.83,34.02 196.66,34.19 196.33,34.19 196.3,34.22 196.3,34.7 197.72,34.7 197.77,34.75 204.96,34.75
+1.05V_RUN on TOP (solid shape): outline of 221 points within 89.32,50.88 102.07,62.72
+1.05V_RUN on BOTTOM (solid shape): 73.62,48.21 73.62,46.69 73.57,46.64 73.39,46.64 73.26,46.77 73.26,46.87 73.03,47.1 72.83,47.1 72.73,47.2 72.73,47.38 72.86,47.5 72.86,47.91 72.73,48.04 72.73,48.26 72.9,48.43 73.4,48.43
+1.05V_RUN on BOTTOM (solid shape): 68.64,47.12 68.7,47.11 68.77,47.12 69.45,47.12 69.52,47.11 69.59,47.12 70.26,47.12 70.33,47.11 70.4,47.12 70.88,47.12 70.95,47.05 70.95,46.7 70.87,46.62 68.09,46.62 68.05,46.62 68.03,46.64 68.03,47.05 68.11,47.12
+1.05V_RUN on BOTTOM (solid shape): outline of 158 points within 68.56,56.06 72.15,57.71
+1.05V_RUN on IN1 (solid shape): 66.79,53.09 66.79,51.72 66.61,51.54 65.31,51.54 65.19,51.67 65.19,53.17 65.34,53.32 66.56,53.32
+1.05V_RUN on IN1 (solid shape): 90.38,62.29 90.38,59.59 90.17,59.38 88,59.38 87.46,59.91 87.46,62.39 87.69,62.62 90.05,62.62
+1.5V_RUN on IN1 (solid shape): 68.23,53.14 68.23,51.77 68.06,51.59 67.22,51.59 67.14,51.67 67.14,52.96 67.4,53.22 68.16,53.22
+1.05V_RUN on IN1 (solid shape): 70.49,46.69 70.49,46.51 70.25,46.27 68.68,46.27 68.41,46.54 68.41,46.92 68.61,47.11 69.38,47.11 69.39,47.12 70.06,47.12
+1.05V_RUN on IN2 (solid shape): 66.91,53.22 66.91,52.07 66.74,51.9 65.39,51.9 65.29,52 65.29,53.19 65.41,53.32 66.81,53.32
+1.05V_RUN on SVCC (solid shape): outline of 81 points within 64.65,45.55 95.72,62.56
+1.5V_RUN on IN3 (solid shape): 68.64,52.25 68.64,51.39 68.56,51.31 67.37,51.31 67.12,51.57 67.12,52.15 67.45,52.48 68.41,52.48
+1.5V_RUN on IN3 (solid shape): 205.19,34.62 205.19,33.48 205.06,33.35 203.92,33.35 203.67,33.61 203.67,34.62 203.79,34.75 205.06,34.75
+1.05V_RUN on IN3 (solid shape): 72.53,57.64 72.53,56.01 72.22,55.71 71.43,55.71 70.47,56.67 69.73,56.67 69.61,56.8 69.61,57.56 69.73,57.69 70.42,57.69 70.75,57.36 71.05,57.36 71.23,57.54 71.23,57.89 71.33,57.99 72.17,57.99
+1.05V_RUN on IN4 (solid shape): 72.85,54.58 73.51,54.58 73.58,54.51 73.58,54.33 73.51,54.26 72.9,54.26 72.79,54.26 72.77,54.24 72.38,54.24 72,54.62 72,55.02 72.01,55.03 72.4,55.03
+1.05V_RUN on IN4 (solid shape): 66.46,53.52 66.46,52.02 65.72,51.29 65.72,49.66 65.82,49.56 66.61,49.56 67.04,49.13 67.04,47.86 67.35,47.55 68.26,47.55 68.62,47.2 70.37,47.2 70.57,46.99 70.57,46.59 70.34,46.36 68.23,46.36 68.08,46.51 68.08,46.72 67.62,47.17 67.37,47.17 67.22,47.02 65.39,47.02 65.24,47.17 65.24,47.43 65.36,47.55 65.95,47.55 66.15,47.76 66.15,48.21 66.14,48.23 66.14,48.33 65.87,48.59 65.87,48.67 65.67,48.87 65.59,48.87 65.21,49.26 65.21,52.96 65.87,53.62 66.35,53.62
+1.05V_SUS on TOP (solid shape): 39.78,42.76 39.78,42.34 39.71,42.27 37.6,42.27 37.45,42.42 37.45,42.77 37.48,42.8 39.75,42.8
+1.05V_SUS on TOP (solid shape): 98.54,49.56 98.54,48.82 98.77,48.82 98.77,49.56 98.82,49.61 98.89,49.61 98.94,49.56 98.94,48.44 98.94,48.44 98.94,46.51 99.2,46.26 100.11,46.26 100.43,46.58 100.43,48.38 100.37,48.44 100.37,49.56 100.39,49.59 100.49,49.59 100.54,49.53 100.54,48.85 100.57,48.82 100.75,48.82 100.77,48.85 100.77,49.59 100.8,49.61 101.05,49.61 101.18,49.48 101.18,45.27 101.46,44.99 101.46,44.58 101.38,44.51 101.03,44.51 100.59,44.07 100.59,43.31 100.58,43.3 100.58,43.15 100.37,42.93 97.6,42.93 97.44,43.08 97.44,43.49 96.42,44.52 96.11,44.52 95.95,44.68 95.95,48.1 96.85,49 97.93,49 98.23,49.31 98.23,49.56 98.28,49.61 98.49,49.61
+1.05V_SUS on BOTTOM (solid shape): 96.23,61.6 94.07,61.6 93.69,61.22 93.69,59.26 93.43,59.01 90.46,59.01 89.82,59.64 89.82,62.13 89.49,62.46 88.73,62.46 88.66,62.54 88.66,63.73 88.45,63.94 87.82,63.94 87.67,64.09 87.67,65.08 87.72,65.13 96.23,65.13
+1.05V_SUS on IN2 (solid shape): outline of 885 points within 69.68,44.86 99.03,57.05
+1.05V_SUS on SVCC (solid shape): 104.1,56.26 104.1,44.87 103.51,44.28 97.58,44.28 96.73,45.12 96.73,52.18 96.69,52.37 96.58,52.54 90.64,58.48 90.64,62.08 90.87,62.31 98.05,62.31
+1.05V_SUS on IN3 (solid shape): 35.62,44.61 35.62,44.01 35.5,43.89 34.31,43.89 34.09,44.11 34.09,44.74 34.35,45 35.24,45
+1.8V_RUN on TOP (solid shape): 179.16,45.17 179.16,44.4 178.9,44.15 173.19,44.15 172.93,44.4 172.93,45.29 173.19,45.55 178.78,45.55
+1.8V_RUN on TOP (solid shape): 180.18,32.31 180.18,28.03 180.13,27.98 179.49,27.98 179.36,28.11 179.36,30.12 179.35,30.12 179.35,30.36 178.9,30.81 177.07,30.81 176.92,30.97 176.92,31.2 176.82,31.3 176.76,31.37 176.69,31.42 176.44,31.68 176.44,32.34 176.55,32.45 180.03,32.45
+1.8V_RUN on BOTTOM (solid shape): 94.29,38.05 95.18,38.05 95.23,38 95.23,37.49 95.08,37.34 94.12,37.34 93.58,36.81 93.58,36.48 93.03,36.48 93.03,36.26 93.58,36.26 93.58,36.03 93.54,35.98 92.72,35.98 92.58,36.13 92.58,36.42 91.73,37.27 89.9,37.27 89.77,37.14 89.19,37.14 88.94,37.39 88.94,37.7 89.16,37.93 90.31,37.93 90.51,38.13 91.35,38.13 91.97,38.75 93.6,38.75
+1.8V_RUN on IN1 (solid shape): 94.02,46.82 94.02,46.64 92.85,45.47 92.52,45.47 92.44,45.55 92.44,46 93.35,46.92 93.91,46.92
+1.8V_RUN on IN2 (solid shape): 177.63,32.08 177.63,30.81 177.51,30.69 176.36,30.69 176.11,30.94 176.11,32.21 176.24,32.34 177.38,32.34
+1.8V_RUN on IN3 (solid shape): 177.48,32.11 177.48,30.79 177.38,30.69 176.36,30.69 176.11,30.94 176.11,32.16 176.22,32.28 177.31,32.28
+1.8V_SUS on TOP (solid shape): 201.15,37.8 202.17,37.8 202.22,37.75 202.22,36.5 202.19,36.48 200.64,36.48 200.26,36.1 196.3,36.1 196.3,36.89 196.81,37.39 196.81,38.1 197.65,38.1 198.41,38.87 200.09,38.87
+1.8V_SUS on BOTTOM (solid shape): 176.18,11.36 176.18,8.25 176.1,8.17 173.95,8.17 173.56,8.56 170.23,8.56 170.22,8.57 167.47,8.57 166.84,9.2 166.84,11.38 167.22,11.77 175.77,11.77
+1.8V_SUS on BOTTOM (solid shape): 96.61,36.81 96.61,35.67 97.14,35.13 98.82,35.13 99.25,34.7 99.25,33.46 99.02,33.23 99.02,32.14 99.07,32.08 99.07,31.63 98.92,31.48 97.88,31.48 97.77,31.58 97.77,33.15 98,33.38 98,33.76 97.5,34.27 96.91,34.27 96,35.18 96,35.56 95.67,35.89 95.55,35.89 95.46,35.98 94.94,35.98 94.94,36.26 95.46,36.26 95.48,36.28 95.48,36.46 95.46,36.48 94.94,36.48 94.94,36.94 96.48,36.94
+1.8V_SUS on IN3 (solid shape): 172.17,20.02 172.17,19.51 171.92,19.26 170.65,19.26 170.52,19.38 170.52,19.64 170.77,19.89 171.28,19.89 171.54,20.15 172.04,20.15
+1.8V_SUS on IN3 (solid shape): 153.83,9.12 153.83,8.39 153.71,8.26 151.42,8.26 151.34,8.34 151.34,8.82 151.75,9.22 153.73,9.22
+1.8V_SUS on IN3 (solid shape): 169,10.82 169,9.94 168.84,9.78 166.56,9.78 166.48,9.86 166.48,10.8 166.74,11.05 168.77,11.05
+1.8V_SUS on IN4 (solid shape): 99.5,31.98 99.5,31.17 99.43,31.09 98.13,31.09 98,31.22 98,31.98 98.1,32.08 99.4,32.08
+1.8V_SUS on IN4 (solid shape): 153.45,8.97 153.45,8.46 153.21,8.22 150.64,8.22 150.4,8.46 150.4,8.97 150.66,9.22 153.2,9.22
+1.8V_SUS on IN4 (solid shape): 202.55,37.87 202.55,36.9 202.08,36.43 200.82,36.43 200.67,36.58 200.67,38.08 200.81,38.22 202.2,38.22
+1.8V_SUS on IN4 (solid shape): 170.65,11.49 170.65,10.27 170.38,10 167.45,10 167.35,10.1 167.35,11 167.47,11.13 169.15,11.13 169.71,11.69 170.44,11.69
+3.3V_ALW on TOP (solid shape): 122.01,48.42 122.01,47.68 122.23,47.68 122.23,48.42 122.29,48.47 122.36,48.47 122.41,48.42 122.41,47.5 121.93,47.02 120.41,47.02 120.25,47.17 120.25,48.32 120.41,48.47 121.96,48.47
+3.3V_ALW on TOP (solid shape): 133.79,65.77 137.55,65.77 137.65,65.66 137.65,64.8 136.97,64.11 136.97,63.69 136.93,63.66 134.22,63.66 133.72,64.16 132.88,64.16 132.72,64.32 132.72,66.37 132.83,66.48 133.08,66.48
+3.3V_ALW on TOP (solid shape): 193.91,27.71 193.91,27.03 193.84,26.97 193.14,26.97 192.93,26.76 192.41,26.76 192.41,27.51 192.21,27.51 192.21,26.76 192.04,26.76 192.01,26.78 192.01,27.53 192.37,27.88 193.74,27.88
+3.3V_ALW on TOP (solid shape): 125.94,48.72 125.94,47.2 125.77,47.02 124.32,47.02 123.83,47.5 123.83,48.42 123.89,48.47 123.96,48.47 124.01,48.42 124.01,47.68 124.24,47.68 124.24,48.42 124.29,48.47 124.42,48.47 124.8,48.85 125.82,48.85
+3.3V_ALW on TOP (solid shape): 171.44,13.97 171.64,13.97 171.64,14.62 171.64,14.76 172.02,14.76 172.5,14.28 174.23,14.28 174.48,14.03 174.48,13.19 173.95,12.65 172.25,12.65 171.26,13.64 171.26,14.74 171.28,14.76 171.44,14.76
+3.3V_ALW on TOP (solid shape): 189.21,43.95 189.21,43.26 189.24,43.24 189.42,43.24 189.44,43.26 189.44,43.95 189.49,44 189.57,44 189.62,43.95 189.62,42.93 189.44,42.75 187.74,42.75 187.56,42.93 187.56,43.74 187.67,43.84 188.45,43.84 188.6,44 189.16,44
+3.3V_ALW on TOP (solid shape): 191.22,43.95 191.22,43.26 191.25,43.24 191.42,43.24 191.45,43.26 191.45,43.95 191.5,44 192.27,44 192.37,43.9 193.13,43.9 193.35,43.67 193.35,43.06 192.92,42.63 191.4,42.63 191.04,42.98 191.04,43.95 191.09,44 191.17,44
+3.3V_ALW on TOP (solid shape): 190.59,28.13 190.59,26.8 190.56,26.77 190.56,26.78 190.46,26.78 190.41,26.83 190.41,27.51 190.38,27.54 190.23,27.54 190.21,27.51 190.21,26.83 190.12,26.74 189.66,26.74 189.53,26.87 188.21,26.87 188.07,27 188.07,28.33 188.22,28.48 188.22,28.48 190.24,28.48
+3.3V_ALW on TOP (solid shape): 165.19,36.38 165.41,36.38 165.41,37.11 165.44,37.14 165.59,37.14 165.59,35.92 164.75,35.08 164.61,35.08 164.45,34.92 164.45,34.62 164.17,34.35 163.69,34.35 163.64,34.4 163.64,34.83 163.74,34.93 163.74,35.44 164.07,35.77 164.07,36.56 164.65,37.14 165.19,37.14
+3.3V_ALW on TOP (solid shape): 169.63,36.78 169.63,36.1 169.28,35.74 169.28,35.18 169.1,35.01 168.18,35.01 167.62,35.56 167.62,35.72 167.35,36 167.14,36 167.02,36.12 167.02,37.08 167.05,37.11 167.15,37.11 167.19,37.06 167.19,36.38 167.22,36.35 167.4,36.35 167.42,36.38 167.42,37.09 167.45,37.11 169.3,37.11
+3.3V_ALW on TOP (solid shape): 98.38,29.95 98.38,28.7 98.13,28.45 97.11,28.45 97.06,28.5 97.06,28.59 97.11,28.64 97.17,28.64 97.82,28.64 97.86,28.67 97.86,28.82 97.82,28.86 97.01,28.86 96.99,28.88 96.99,29.47 97.11,29.6 97.55,29.6 97.67,29.72 97.67,30.15 97.75,30.23 98.1,30.23
+3.3V_ALW on BOTTOM (solid shape): 138.54,28.96 138.54,28.67 140.03,27.18 140.03,27.17 141.67,25.53 145.22,25.53 145.23,25.52 145.97,25.52 146.94,24.55 146.94,19.87 145.5,19.87 145.11,19.48 145.11,18.94 144.9,18.72 144.26,18.72 142.73,20.25 140.7,20.25 140.5,20.45 140.5,20.48 140.32,20.65 139.96,20.65 139.9,20.72 139.9,20.74 139.73,22.02 139.11,23.16 137.7,24.22 135.96,24.49 134.42,24.49 134.19,24.72 133.41,24.72 133.06,25.08 133.06,27.39 133.56,27.89 134.84,27.89 136.03,29.08 138.42,29.08
+3.3V_ALW on IN1 (solid shape): 188.94,36.78 188.94,30.43 190.21,29.16 194.02,29.16 196.43,26.75 196.43,18.24 196.3,18.11 195.41,18.11 195.29,18.24 195.29,25.1 193.25,27.13 188.3,27.13 187.16,28.27 187.16,28.35 191.42,28.35 191.43,28.3 191.44,28.25 191.46,28.2 191.49,28.15 191.52,28.11 191.56,28.07 191.6,28.04 191.65,28.02 191.7,28 191.75,28 191.81,28 191.86,28 191.91,28.02 191.96,28.04 192,28.07 192.04,28.11 192.07,28.15 192.1,28.2 192.12,28.25 192.13,28.3 192.14,28.35 192.13,28.4 192.12,28.46 192.1,28.51 192.07,28.55 192.04,28.59 192,28.63 191.96,28.66 191.91,28.68 191.86,28.7 191.81,28.71 191.75,28.71 191.7,28.7 191.65,28.68 191.6,28.66 191.56,28.63 191.52,28.59 191.49,28.55 191.46,28.51 191.44,28.46 191.43,28.4 191.42,28.35 187.16,28.35 187.16,36.53 185.76,37.93 185.76,38.82 185.89,38.94 186.78,38.94
+3.3V_ALW on IN2 (solid shape): 171.21,14.18 173.7,14.18 174.41,13.47 174.41,13.21 173.82,12.63 171.49,12.63 169.55,14.56 163.66,14.56 163.54,14.69 163.54,15.75 163.66,15.88 169.5,15.88
+3.3V_ALW on SVCC (solid shape): outline of 487 points within 119.97,13.49 193.38,50.75
+3.3V_ALW on IN3 (solid shape): 167.52,48.57 167.52,48.32 167.78,48.06 168.26,48.06 168.56,47.76 168.56,47.17 168.23,46.84 167.33,46.84 166.95,47.21 166.95,48.58 166.99,48.62 167.47,48.62
+3.3V_DEEP_SLEEP_OFF on TOP (solid shape): 75.59,50.83 75.59,49.44 75.86,49.17 75.86,47.14 75.8,47.09 75.46,47.09 75.39,47.16 75.39,48.77 74.96,49.2 74.75,49.2 74.73,49.22 74.73,50.86 74.84,50.96 75.45,50.96
+3.3V_DEEP_SLEEP_OFF on TOP (solid shape): 90.99,45.08 90.99,44.54 91.15,44.38 91.75,44.38 91.83,44.3 91.83,43.79 92.59,43.03 92.59,40.58 92.1,40.09 91.01,40.09 90.47,40.62 90.47,41.01 90.59,41.13 90.81,41.13 91.09,40.85 92.03,40.85 92.2,41.02 92.2,42.76 92.03,42.93 90.99,42.93 90.69,42.63 89.61,42.63 89.61,42.95 90.38,42.95 90.38,43.27 89.61,43.27 89.61,43.6 90.37,43.6 90.37,44.27 89.61,44.27 89.61,44.6 90.38,44.6 90.38,44.92 89.61,44.92 89.61,45.19 89.72,45.31 90.76,45.31
+3.3V_DEEP_SLEEP_OFF on TOP (solid shape): 167.48,30.38 167.48,30.15 166.7,29.36 166.7,26.99 166.66,26.83 166.7,26.66 166.7,25.16 167.32,24.54 167.86,24.54 169.79,22.61 172,22.61 172.9,23.5 177.89,23.5 178.62,24.24 180.17,24.24 180.19,24.21 180.19,23.35 180.7,22.85 180.97,22.85 181.39,22.42 181.39,22.41 181.5,22.19 181.72,22.08 181.74,22.08 182.95,20.87 182.95,19.57 183.37,19.15 183.37,18.2 183.31,18.13 182.54,18.13 182.46,18.21 182.46,20.29 181.23,21.53 181.19,21.58 181.14,21.61 180.52,22.24 180.06,22.24 179.2,23.1 173.25,23.1 172.18,22.03 169.72,22.03 167.59,24.16 167.07,24.16 166.24,24.99 166.24,29.77 166.98,30.52 167.35,30.52
+3.3V_DEEP_SLEEP_OFF on TOP (solid shape): 74.91,44.13 74.91,43.89 74.8,43.77 74.8,43.69 74.18,43.07 74.18,42.51 74.35,42.35 74.35,41.51 74.4,41.45 74.4,41.44 74.47,41.3 74.61,41.23 74.62,41.23 74.66,41.2 75.61,41.2 75.61,41.2 77.04,41.2 77.11,41.12 77.11,40.82 76.96,40.66 76.11,40.66 76.03,40.59 76.01,40.58 75.86,40.51 75.78,40.36 75.78,40.34 75.35,39.91 75.35,39.52 75.3,39.47 74.67,39.47 74.3,39.85 74.3,41.22 74.04,41.48 73.67,41.48 73.39,41.76 73.39,42.39 73.39,42.4 73.39,43.31 73.73,43.65 73.77,43.65 73.93,43.71 74,43.87 74,43.92 74.38,44.3 74.74,44.3
+3.3V_DEEP_SLEEP_OFF on BOTTOM (solid shape): 90.56,46.87 90.56,46.84 91.58,46.84 91.88,46.54 91.88,45.98 91.55,45.65 91.55,43.54 91.78,43.31 91.78,43.01 91.71,42.94 91.25,42.94 91.24,42.93 91.04,42.93 90.94,43.03 90.94,45.93 90.76,46.11 89.89,46.11 89.75,45.97 89.75,42.92 89.7,42.87 89.54,42.87 89.49,42.93 89.49,46.25 89.72,46.48 89.72,46.89 89.77,46.94 90.48,46.94
+3.3V_DEEP_SLEEP_OFF on IN1 (solid shape): 74.25,43.54 74.25,42.52 73.9,42.17 73.52,42.17 73.42,42.27 73.42,42.88 73.19,43.11 73.19,43.59 73.24,43.64 74.15,43.64
+3.3V_DEEP_SLEEP_OFF on IN1 (solid shape): 81.52,47.83 83.3,47.83 83.63,47.51 83.63,47.17 83.25,46.79 82.94,46.79 82.33,47.4 81.11,47.4 80.35,48.16 80.35,48.73 80.63,48.73
+3.3V_DEEP_SLEEP_OFF on IN1 (solid shape): 74.66,50.27 74.66,49.92 74.94,49.64 75.35,49.64 75.65,49.33 76.21,49.33 76.29,49.26 76.29,48.75 76.26,48.72 74.81,48.72 73.72,49.81 73.72,50.35 73.85,50.47 74.46,50.47
+3.3V_DEEP_SLEEP_OFF on IN2 (solid shape): 74.74,50.4 74.74,49.99 74.67,49.93 72.77,49.93 72.68,50.02 72.68,50.4 72.78,50.5 74.64,50.5
+3.3V_DEEP_SLEEP_OFF on IN2 (solid shape): outline of 92 points within 67.27,45.75 69.28,49.36
+3.3V_DEEP_SLEEP_OFF on IN3 (solid shape): 157.67,42.64 157.67,42.17 157.57,42.07 156.5,42.07 156.39,42.18 156.39,42.94 156.44,42.99 157.31,42.99
+3.3V_DEEP_SLEEP_OFF on IN3 (solid shape): 84.46,46.89 86.34,46.89 86.4,46.84 86.4,46.41 86.31,46.32 84.08,46.32 83.22,47.19 83.22,47.38 83.37,47.53 83.83,47.53
+3.3V_DEEP_SLEEP_OFF on IN4 (solid shape): 69.81,47.62 70.55,47.62 70.97,47.2 70.97,46.76 71.23,46.5 71.49,46.5 71.67,46.32 71.67,46.2 71.58,46.11 71.47,46.11 71.47,46.11 71.19,46.11 70.68,46.63 70.68,47.05 70.41,47.32 69.57,47.32 68.51,48.38 67.38,48.38 67.28,48.48 67.28,48.62 67.46,48.8 68.63,48.8
+3.3V_EC on TOP (solid shape): 133.84,63.43 133.84,62.13 133.97,62.01 135.29,62.01 135.65,62.36 135.85,62.36 135.98,62.23 135.98,61.45 135.79,61.26 133.85,61.26 132.8,62.31 132.8,63.63 132.88,63.71 133.56,63.71
+3.3V_EC on TOP (solid shape): outline of 163 points within 135.66,54.62 140.14,59.26
+3.3V_EC on IN1 (solid shape): 137.04,58.65 137.04,57.97 136.92,57.84 135.98,57.84 135.87,57.94 135.87,58.75 135.98,58.86 136.84,58.86
+3.3V_EC on IN2 (solid shape): 136.48,61.93 136.48,59.54 136.99,59.03 136.99,58.22 137.03,58.18 137.03,57.9 136.97,57.84 136.05,57.84 135.75,58.15 135.75,59.16 135.48,59.43 135.48,62.27 135.62,62.41 136,62.41
+3.3V_EC on IN3 (solid shape): 137.28,58.43 137.28,57.91 137.15,57.78 135.75,57.78 135.69,57.84 135.69,58.72 135.85,58.88 136.83,58.88
+3.3V_RTC_LDO on TOP (solid shape): 124.05,59.05 124.05,57.8 123.56,57.31 123.1,57.31 122.9,57.51 122.9,58.09 122.84,58.15 122.84,59.1 122.88,59.14 123.96,59.14
+3.3V_RTC_LDO on TOP (solid shape): 152.27,37.75 152.27,36.75 152.5,36.52 153.52,36.52 153.93,36.1 154.83,36.1 155.54,35.39 155.54,34.49 155.33,34.28 154.94,34.28 154.86,34.36 154.86,34.66 155.06,34.86 155.06,35.14 154.7,35.5 153.62,35.5 153.58,35.54 153.58,35.93 153.33,36.17 152.38,36.17 152.07,36.48 152.07,37.79 152.08,37.8 152.21,37.8
+3.3V_RTC_LDO on IN2 (solid shape): 124.52,59.39 124.52,59.23 124.33,59.04 124.33,58.69 124.23,58.59 123.55,58.59 123.38,58.76 123.38,59.39 123.54,59.55 124.37,59.55
+3.3V_RUN on TOP (solid shape): 185.53,30.7 185.53,30.28 185.1,29.85 184.33,29.85 184.33,29.84 184.22,29.84 184.2,29.86 184.2,30.47 184.54,30.81 185.41,30.81
+3.3V_RUN on TOP (solid shape): 69.71,58.7 69.71,58.6 69.63,58.53 69.63,57.1 69.53,57 68.84,57 68.77,57.08 68.77,57.81 68.64,57.94 68.64,58.73 68.72,58.81 69.61,58.81
+3.3V_RUN on TOP (solid shape): 162.39,45.61 162.39,44.96 162.54,44.81 163.08,44.81 163.25,44.63 163.25,43.93 163.1,43.78 161.47,43.78 161.31,43.94 161.31,45.32 161.87,45.32 161.9,45.34 161.9,45.51 161.86,45.54 161.31,45.54 161.31,45.83 162.16,45.83
+3.3V_RUN on TOP (solid shape): 125.94,52.07 125.94,51.52 126.64,50.82 129.74,50.82 130.22,50.34 130.22,48.32 130.08,48.19 126.65,48.19 126.12,48.72 126.12,49.05 125.82,49.36 125.05,49.36 124.65,49.76 124.29,49.76 124.24,49.81 124.24,50.5 124.22,50.53 124.04,50.53 124.01,50.5 124.01,49.81 123.96,49.76 123.89,49.76 123.83,49.81 123.83,50.78 125.18,52.13 125.89,52.13
+3.3V_RUN on TOP (solid shape): outline of 129 points within 74.37,50.25 88.35,60.55
+3.3V_RUN on BOTTOM (solid shape): 177.68,44.53 177.68,43.92 177.28,43.51 174.46,43.51 174.33,43.64 174.33,44.4 174.58,44.66 177.56,44.66
+3.3V_RUN on BOTTOM (solid shape): 184.36,42.63 184.36,42.12 184.24,41.99 180.3,41.99 180.17,42.12 180.17,43.13 180.3,43.26 183.73,43.26
+3.3V_RUN on BOTTOM (solid shape): 24.72,60.56 24.72,60.35 24.5,60.13 24.5,58.65 24.47,58.63 24.37,58.63 24.32,58.68 24.32,59.39 24.29,59.42 24.14,59.42 24.11,59.39 24.11,58.68 24.06,58.63 23.96,58.63 23.94,58.65 23.94,60.46 24.27,60.79 24.5,60.79
+3.3V_RUN on BOTTOM (solid shape): 95.46,58.48 95.46,54.97 95.18,54.69 95.18,50.8 93.74,49.36 90.79,49.36 90.76,49.38 90.76,51.36 90.59,51.54 89.6,51.54 89.27,51.87 88.73,51.87 88.33,52.28 88.33,53.37 88.27,53.42 87.84,53.42 87.36,53.9 87.36,55.02 87.56,55.22 88.12,55.22 88.45,55.55 88.45,55.85 88.55,55.95 89.04,55.95 89.08,55.9 89.08,55.13 89.18,55.03 89.18,52.72 89.19,52.71 89.19,52.51 89.75,51.95 92.95,51.95 93.35,51.54 93.99,51.54 94.42,51.97 94.42,54.67 94.65,54.89 94.65,58.48 94.73,58.55 95.39,58.55
+3.3V_RUN on BOTTOM (solid shape): outline of 85 points within 201.84,51.21 208.49,55.61
+3.3V_RUN on IN1 (solid shape): 75.09,59.85 75.37,59.85 75.4,59.82 75.4,59.26 75.35,59.21 73.52,59.21 73.49,59.24 73.49,59.92 73.54,59.97 74.97,59.97
+3.3V_RUN on IN1 (solid shape): 106.46,39.96 106.46,39.68 106.37,39.59 106.14,39.59 104.86,40.87 104.86,41.05 104.96,41.15 105.27,41.15
+3.3V_RUN on IN1 (solid shape): 185.53,30.99 185.53,30.31 185.28,30.05 184.26,30.05 183.4,30.92 183.4,31.55 183.91,32.06 184.46,32.06
+3.3V_RUN on IN1 (solid shape): 70.65,58.78 70.65,58.5 70.27,58.12 68.95,58.12 68.67,58.4 68.67,58.75 68.74,58.83 69.56,58.83 69.63,58.75 69.96,58.75 70.09,58.88 70.55,58.88
+3.3V_RUN on IN1 (solid shape): 181.65,56.88 181.65,55.27 181.24,54.87 181.24,53.65 185.15,49.74 185.15,49.43 183.96,48.24 183.09,48.24 179.33,52 179.33,55.76 179.84,56.27 179.84,56.82 180.17,57.15 181.37,57.15
+3.3V_RUN on IN2 (solid shape): outline of 227 points within 177.79,26.42 185.68,30.98
+3.3V_RUN on SVCC (solid shape): outline of 229 points within 119.97,46.94 205.7,66.91
+3.3V_RUN on IN3 (solid shape): 96.02,58.55 96.02,57.87 95.79,57.64 94.24,57.64 94.12,57.76 94.12,58.55 94.22,58.65 95.92,58.65
+3.3V_RUN on IN3 (solid shape): 129.47,60.2 129.47,59.54 129.4,59.47 127.85,59.47 127.77,59.54 127.77,60.2 127.85,60.28 129.4,60.28
+3.3V_RUN on IN3 (solid shape): 179.11,29.42 179.11,28.35 178.98,28.22 178.17,28.22 178.06,28.33 178.06,29.49 178.24,29.67 178.85,29.67
+3.3V_RUN on IN3 (solid shape): 69,58.83 69.5,58.83 69.76,58.58 69.76,58.32 69.56,58.12 68.44,58.12 68.16,58.4 68.16,59.06 68.18,59.08 68.74,59.08
+3.3V_RUN on IN3 (solid shape): 85.99,52.71 85.99,52.3 86.22,52.07 86.59,52.07 86.7,52.05 86.81,52.07 87.59,52.07 88.05,52.53 89.37,52.53 89.44,52.46 89.44,51.59 89.37,51.52 85.91,51.52 85.66,51.77 85.66,52.71 85.71,52.76 85.94,52.76
+3.3V_RUN_DPF1 on BOTTOM (solid shape): 210.83,59.36 210.83,59.01 210.82,59 208.86,59 208.75,58.88 208.75,57.97 208.9,57.81 208.9,55.3 208.49,54.89 206.77,54.89 206.3,55.36 206.3,55.85 205.75,56.39 205.75,57.05 206.08,57.38 207.11,57.38 207.48,57.75 207.48,58.63 207.22,58.88 207.22,59.34 207.28,59.4 210.8,59.4
+3.3V_SUS on TOP (solid shape): 104.73,42.45 104.73,41.61 104.63,41.51 103.77,41.51 103.67,41.61 103.67,42.42 103.74,42.5 104.68,42.5
+3.3V_SUS on TOP (solid shape): 121.02,53.46 121.02,51.29 121.5,51.77 121.9,51.77 122.41,51.26 122.41,49.81 122.36,49.76 122.29,49.76 122.23,49.81 122.23,50.5 122.21,50.53 122.03,50.53 122.01,50.5 122.01,49.81 121.96,49.76 120.3,49.76 120.08,49.53 120.08,48.8 120.02,48.75 119.49,48.75 119.44,48.8 119.44,53.52 119.58,53.66 120.81,53.66
+3.3V_SUS on BOTTOM (solid shape): 93.13,40.01 93.56,40.01 93.66,39.91 93.66,39.43 93.91,39.17 93.91,39.04 93.81,38.94 92.44,38.94 91.78,39.6 91.78,40.59 91.91,40.72 92.42,40.72
+3.3V_SUS on BOTTOM (solid shape): 100.91,55.41 100.91,54.67 100.81,54.56 99.58,54.56 99.37,54.77 98.41,54.77 98.22,54.58 96.57,54.58 96.17,54.18 96.17,48.7 96.89,47.99 100.82,47.99 101.41,47.4 101.41,45.95 101.22,45.76 99.49,45.76 99.07,46.18 99.07,46.48 98.43,47.12 96.68,47.12 95.36,48.44 95.36,54.49 96.71,55.83 100.49,55.83
+3.3V_SUS on IN1 (solid shape): 104.56,43.34 104.56,42.02 104.33,41.79 104,41.79 103.82,41.97 103.82,43.34 103.92,43.44 104.45,43.44
+3.3V_SUS on IN3 (solid shape): 121.14,53.62 121.14,53.29 120.79,52.94 119.39,52.94 119.26,53.07 119.26,53.62 119.36,53.73 121.04,53.73
+3.3V_SUS on IN3 (solid shape): 101.56,54.82 101.56,54.06 101.43,53.93 100.49,53.93 99.78,54.64 99.78,54.79 99.93,54.94 101.43,54.94
+3.3V_SUS on IN3 (solid shape): 93.22,34.46 93.22,33.52 93.18,33.48 92.43,33.48 92.25,33.66 92.25,34.41 92.42,34.58 93.1,34.58
+3.3V_SUS on IN3 (solid shape): 104.56,43.62 104.56,43.21 104.43,43.08 104.18,43.08 103.87,43.39 100.8,43.39 99.81,44.38 98.28,44.38 98.05,44.15 95.56,44.15 94.88,44.84 94.07,44.84 93.89,45.01 93.89,45.56 93.58,45.86 93.25,45.86 92.75,45.36 92.05,45.36 92.01,45.39 92.01,45.9 92.11,46 92.31,46 93,46.69 95.64,46.69 96.96,45.37 98.52,45.37 98.71,45.33 98.9,45.37 98.97,45.37 99.16,45.56 99.16,46.69 99.29,46.82 101.36,46.82
+3.3V_SUS on IN4 (solid shape): 93.99,39.04 93.99,36.12 93.89,35.87 93.99,35.62 93.99,33.89 93.76,33.66 93.08,33.66 92.92,33.81 92.92,39.07 93.05,39.2 93.84,39.2
+3.3V_THERMAL on TOP (solid shape): 175.75,22.15 175.75,21.65 175.35,21.24 175.35,17.17 175.22,17.05 175.22,15.73 175.19,15.7 174.46,15.7 174.25,15.9 174.25,17.12 174.08,17.3 174.08,21.59 174.71,22.23 175.68,22.23
+3.3V_TPM on TOP (solid shape): 154.62,48.11 154.62,46.41 155.1,45.93 156.09,45.93 157.39,44.63 157.39,43.72 157.19,43.51 155.76,43.51 152.92,46.36 151.09,46.36 150.97,46.47 150.97,48.07 151.17,48.26 154.47,48.26
+5V_ALW on TOP (solid shape): 115.53,49.49 115.53,47.83 115.4,47.71 114.89,47.71 114.77,47.83 114.77,49.47 114.85,49.55 115.46,49.55
+5V_ALW on TOP (solid shape): 169.44,14.62 169.44,13.97 169.64,13.97 169.64,14.62 169.64,14.62 169.64,14.76 169.81,14.76 169.84,14.73 169.84,13.64 169.38,13.18 167.96,13.18 167.85,13.28 167.85,14.15 168.16,14.46 168.69,14.46 169,14.76 169.44,14.76
+5V_ALW on TOP (solid shape): 201.53,23.96 201.53,23.46 201.36,23.29 201.36,21.54 201.3,21.49 200.62,21.49 200.59,21.47 200.59,21.29 200.62,21.26 201.3,21.26 201.36,21.21 201.36,21.11 201.33,21.09 200.34,21.09 200.16,21.26 200.16,23.88 200.31,24.03 201.46,24.03
+5V_ALW on TOP (solid shape): 98.71,27.54 99.07,27.54 99.35,27.26 99.35,26.4 99.27,26.32 98.92,26.32 98.36,26.88 98.36,27.31 98.02,27.65 97.1,27.65 97.05,27.7 97.05,27.78 97.1,27.83 97.81,27.83 97.91,27.94 98.31,27.94
+5V_ALW on TOP (solid shape): 163.46,56.27 163.46,48.04 163.15,47.73 163.15,47.2 162.95,46.99 162.24,46.99 161.66,47.58 158,47.58 157.79,47.78 157.79,48.54 158.05,48.8 161.88,48.8 162.09,49 162.09,56.27 162.21,56.39 163.33,56.39
+5V_ALW on TOP (solid shape): 198.51,48.82 198.51,47.55 198.69,47.38 198.69,45.72 198.66,45.7 197.34,45.7 197.22,45.83 196.67,45.83 196.47,45.62 196,45.62 195.92,45.7 195.92,48.98 196.2,49.26 198.08,49.26
+5V_ALW on TOP (solid shape): 201.36,19.61 201.36,19.54 201.3,19.49 200.59,19.49 200.57,19.46 200.57,19.28 200.59,19.26 201.3,19.26 201.36,19.21 201.36,19.09 202.02,18.43 202.02,17.28 201.86,17.12 200.29,17.12 200.19,17.23 200.19,19.28 200.57,19.66 201.3,19.66
+5V_ALW on TOP (solid shape): 144.81,47.3 145.1,47.3 145.1,48.36 145.78,48.36 145.79,48.35 145.79,46.59 145.88,46.5 148.15,46.5 148.15,46.5 148.32,46.5 148.45,46.36 148.45,44.39 148.19,44.12 146.85,44.12 145.79,43.07 145.79,41.92 144.97,41.09 144.97,39.32 144.94,39.3 143.72,39.3 143.62,39.4 143.62,40.57 144.13,41.08 144.28,41.08 144.44,41.23 144.44,41.98 144.82,42.36 144.82,43.96 144.15,44.62 144.15,44.77 145.1,44.77 145.1,45.77 144.82,45.77 144.82,44.77 144.15,44.77 144.15,48.36 144.15,48.36 144.81,48.36
+5V_ALW on BOTTOM (solid shape): 187.41,10.8 187.41,7.07 187.23,6.89 185.3,6.89 185.21,6.8 181.4,6.8 181.37,6.84 181.37,8.62 181.54,8.79 184.77,8.79 184.9,8.92 184.9,9.47 185.9,9.47 185.9,9.67 184.9,9.67 184.9,9.97 185.9,9.97 185.9,10.17 184.9,10.17 184.9,10.42 184.95,10.47 186.09,10.47 186.57,10.95 187.26,10.95
+5V_ALW on BOTTOM (solid shape): 21.05,34 21.05,32.4 21.25,32.4 21.25,34 21.28,34.03 21.51,34.03 21.54,34 21.54,32.4 21.75,32.4 21.75,33.99 21.79,34.03 22.02,34.03 22.05,34.01 22.05,32.4 22.25,32.4 22.25,34 22.29,34.04 22.51,34.04 22.55,34 22.55,32.4 22.75,32.4 22.75,34.01 22.77,34.03 23.03,34.03 23.05,34.01 23.05,32.08 21.92,30.95 20.16,30.95 19.93,30.72 19.93,30.41 19.72,30.19 18.37,30.19 17.89,30.68 17.89,31.2 18.05,31.36 18.59,31.36 18.8,31.57 19.08,31.57 19.77,32.25 20.59,32.25 20.76,32.42 20.76,34.02 20.8,34.05 21,34.05
+5V_ALW on BOTTOM (solid shape): 167.78,27.69 167.78,27.18 167.73,27.13 167.27,27.13 166.91,27.19 166.67,26.91 166.61,26.85 166.61,25.35 167.7,24.26 167.7,22.84 167.5,22.64 167.12,22.64 166.94,22.46 166.94,21.57 166.79,21.42 165.72,21.42 165.49,21.65 165.49,22.79 165.36,22.92 162.87,22.92 162.7,22.74 162.7,21.06 162.21,20.58 158.23,20.58 157.93,20.87 157.93,25.46 158.19,25.71 161.93,25.71 163.81,27.59 164.04,27.59 164.18,27.73 167.74,27.73
+5V_ALW on IN1 (solid shape): 150.3,45.95 150.3,45.06 150.2,44.96 148.28,44.96 148.14,45.1 148.14,46.03 148.24,46.13 150.12,46.13
+5V_ALW on IN1 (solid shape): 162.82,47.68 162.82,47.58 163.1,47.3 163.1,46.89 163.03,46.82 162.04,46.82 161.96,46.89 161.96,47.71 162.09,47.83 162.67,47.83
+5V_ALW on SVCC (solid shape): outline of 719 points within 8.72,5.91 202.27,50.75
+5V_ALW on IN3 (solid shape): 163.79,56.34 163.79,55.83 163.54,55.58 162.01,55.58 161.88,55.71 161.88,56.47 162.01,56.6 163.54,56.6
+5V_ALW2 on IN1 (solid shape): 152.02,49.88 152.02,49.37 151.77,49.13 150.3,49.13 150.05,49.38 150.05,49.92 150.1,49.97 151.93,49.97
+5V_ALW2 on IN3 (solid shape): 152.05,49.86 152.05,49.43 151.75,49.13 150.1,49.13 149.9,49.33 148.63,49.33 148.57,49.38 148.57,49.79 148.69,49.9 152.02,49.9
+5V_FAN on TOP (solid shape): 165.69,19.56 165.69,16.08 165.57,15.96 164.17,15.96 163.61,16.51 163.61,19.56 163.84,19.79 165.47,19.79
+5V_FAN on BOTTOM (solid shape): 21.17,38.99 21.17,37.75 21.05,37.63 21.05,35.94 21.45,35.54 21.45,35.31 21.3,35.16 20.84,35.16 20.61,35.39 20.61,35.87 20.75,36.01 20.75,37.61 20.28,38.08 20.28,38.97 20.38,39.07 21.09,39.07
+5V_FAN on IN2 (solid shape): 164.6,17.76 164.6,16.72 164.32,16.44 163.51,16.44 163.41,16.54 163.41,17.76 163.59,17.94 164.42,17.94
+5V_FAN_R on TOP (solid shape): 169.25,18.78 169.25,17.71 169.83,17.12 169.83,16.03 169.81,16.01 169.64,16.01 169.64,16.12 169.64,16.12 169.64,16.77 169.44,16.77 169.44,16.17 169.44,16.17 169.44,16.01 169.11,16.01 169.06,15.96 166.48,15.96 166.33,16.11 166.33,17.38 166.51,17.56 168.16,17.56 168.34,17.73 168.34,18.78 168.46,18.9 169.12,18.9
+5V_PTC on TOP (solid shape): 137.31,45.66 140.18,45.66 140.68,45.17 142.58,45.17 143.22,45.81 143.82,45.81 143.88,45.75 143.88,44.4 144,44.28 144,42.16 143.9,42.07 142.88,42.07 142.81,42.14 142.81,43.1 142.55,43.36 141.72,43.36 141.31,43.77 138.31,43.77 137.93,44.15 137.47,44.15 137.17,43.84 137.17,43.67 136.46,42.96 136.46,41.2 136.71,40.95 136.71,40.52 136.48,40.29 136.04,40.29 135.51,39.76 135.51,39.41 134.72,39.41 134.72,39.97 134.99,40.24 134.99,42.7 136.36,44.07 136.36,45.27 135.8,45.83 132.6,45.83 132.39,45.62 129.78,45.62 129.63,45.78 128.69,45.78 127.59,44.68 127.59,44.3 127.95,43.95 128.34,43.95 129.17,43.11 129.17,42.03 128.86,41.72 127.42,41.72 127.03,41.33 127.03,40.93 126.94,40.84 126.52,40.84 126.47,40.88 126.47,41.26 126.86,41.64 126.86,41.64 127.11,41.89 127.11,43.46 126.71,43.87 126.71,44.91 126.98,45.19 126.98,45.42 128.24,46.68 131.95,46.68 132.04,46.77 136.2,46.77
+5V_RUN on TOP (solid shape): 167.36,21.07 167.36,18.38 167.29,18.32 166.3,18.32 166.24,18.38 166.24,19.42 165.72,19.94 165.72,20.86 166.09,21.23 167.21,21.23
+5V_RUN on TOP (solid shape): 199.2,57.05 199.2,54.42 198.73,53.95 198.34,53.95 198.28,54 198.28,54.89 198.91,55.51 198.91,57.1 198.97,57.16 199.09,57.16
+5V_RUN on TOP (solid shape): 193.2,35.64 194.4,35.64 194.45,35.59 194.45,35.21 194.42,35.18 193.28,35.18 193.15,35.06 191.93,35.06 191.75,35.23 191.75,35.84 191.88,35.97 192.87,35.97
+5V_RUN on TOP (solid shape): 97.89,27.03 97.94,27 97.99,26.97 99.22,25.73 99.22,24.24 99.05,24.06 97.62,24.06 97.44,24.24 97.44,25.76 97.03,26.17 97.03,26.56 97.04,26.57 97.04,26.62 97.8,26.62 97.8,26.85 97.04,26.85 97.04,27.03 97.04,27.03
+5V_RUN on TOP (solid shape): 208.37,20.15 208.37,17.48 207.45,16.57 204.96,16.57 204.73,16.79 204.73,17.35 204.4,17.68 203.44,17.68 203.31,17.81 203.31,18.17 202.68,18.8 202.68,19.21 202.73,19.26 203.41,19.26 203.44,19.28 203.44,19.46 203.41,19.49 202.73,19.49 202.68,19.54 202.68,19.61 202.73,19.66 203.67,19.66 203.97,19.36 206.46,19.36 206.66,19.56 206.66,19.97 207.1,20.4 208.11,20.4
+5V_RUN on BOTTOM (solid shape): 15.99,52.4 15.99,51.64 16.11,51.52 16.11,50.96 16.01,50.86 15.53,50.86 15.4,50.98 15.4,51.49 15.81,51.9 15.81,52.43 15.83,52.46 15.94,52.46
+5V_RUN on BOTTOM (solid shape): 169.53,22.15 169.53,21.62 169.43,21.52 168.89,21.52 168.62,21.24 168.62,20.83 167.57,19.79 165.72,19.79 165.67,19.84 165.67,20.55 165.95,20.83 166.84,20.83 167.12,21.11 167.12,22.36 167.19,22.43 169.25,22.43
+5V_RUN on IN1 (solid shape): 199.35,57.08 199.35,55.91 199.1,55.66 198.76,55.66 198.54,55.88 198.54,57.28 199.15,57.28
+5V_RUN on IN2 (solid shape): 193.46,35.87 193.46,35.31 193.35,35.21 191.68,35.21 191.45,35.44 191.45,35.89 191.58,36.02 193.3,36.02
+5V_RUN on IN2 (solid shape): 104.61,9.86 104.61,8.08 104.23,7.7 100.59,7.7 100.21,8.08 100.21,9.81 100.64,10.24 104.23,10.24
+5V_RUN on IN2 (solid shape): outline of 541 points within 177.63,7.32 208.75,20.53
+5V_RUN on IN4 (solid shape): outline of 131 points within 98,8.26 102.93,25.4
+5V_SUS on TOP (solid shape): 207.86,24.13 207.86,23.14 206.84,22.13 204.45,22.13 204.07,21.75 204.07,21.57 203.59,21.09 202.73,21.09 202.7,21.11 202.7,21.24 202.73,21.26 203.44,21.26 203.46,21.29 203.46,21.47 203.44,21.49 202.75,21.49 202.7,21.54 202.7,21.95 202.55,22.1 202.55,23.22 202.88,23.55 205.93,23.55 206.64,24.26 207.73,24.26
+15V_ALW on TOP (solid shape): 138.63,43.2 140.2,43.2 140.34,43.06 140.34,41.89 140.19,41.74 139.91,41.74 139.63,42.02 139.13,42.02 138.95,41.84 138.95,41.2 139.78,40.37 139.78,39.35 139.74,39.31 138.34,39.31 138.33,39.32 138.33,40.48 138.06,40.75 138.06,42.27 137.96,42.37 137.07,42.37 136.98,42.46 136.98,43.07 136.99,43.08 136.99,43.13 137.4,43.54 137.4,43.77 137.58,43.95 137.88,43.95
+DVDD-25-LDO-O on TOP (solid shape): 112.54,38.18 112.54,37.57 112.68,37.42 113.65,37.42 113.72,37.49 113.72,38.05 113.88,38.21 114.45,38.21 114.45,38.13 114.72,37.86 114.72,36.07 114.98,35.81 114.97,35.79 114.97,34.17 115.55,33.58 115.55,33.15 115.15,32.75 114.01,32.75 113.9,32.85 113.9,34.42 114.28,34.8 114.28,37.01 114.13,37.16 112.28,37.16 111.77,36.66 111.77,35.46 111.52,35.21 110.07,35.21 110.05,35.23 110.05,35.49 110.07,35.51 111.06,35.51 111.06,35.51 111.21,35.67 111.21,37.83 111.22,37.84 111.22,38.07 111.57,38.41 112.31,38.41
+V1.05A_AOSCSUS on TOP (solid shape): 94.37,48.79 95.22,48.79 95.56,48.44 95.56,46.99 95.51,46.94 94.5,46.94 92.95,48.49 89.62,48.49 89.14,48.98 89.14,49.76 89.24,49.86 93.29,49.86
+V1.05DX_MODPHY on TOP (solid shape): 55.25,64.37 55.25,62.95 55.1,62.79 53.32,62.79 53.2,62.92 53.2,64.47 53.25,64.52 55.1,64.52
+V1.05DX_MODPHY on TOP (solid shape): 95.54,44.07 96.56,44.07 97.19,43.44 97.19,43.01 97.47,42.73 98.97,42.73 99.25,42.45 99.25,41 99.1,40.85 97.6,40.85 96.96,40.21 95.46,40.21 95.31,40.06 93.2,40.06 93.02,40.24 93.02,41.52 98.93,41.52 98.93,42.31 98.6,42.31 98.6,41.52 93.02,41.52 93.02,41.52 98.28,41.52 98.28,42.31 97.94,42.31 97.94,41.52 93.02,41.52 93.02,44.33 93.13,44.43 95.18,44.43
+V1.05DX_MODPHY on TOP (solid shape): 77.61,66.98 77.61,66.75 72.87,62.01 72.87,61.43 72.27,60.84 72.27,60.38 72.04,60.15 72.04,59.9 72.07,59.87 72.07,59.8 72.93,58.93 74.03,58.93 74.61,58.35 75.42,58.35 75.65,58.12 75.65,55.53 75.57,55.45 74.89,55.45 74.2,54.77 74.2,53.5 74.13,53.42 73.75,53.42 73.62,53.55 73.62,56.01 73.82,56.21 74.71,56.21 74.91,56.42 74.91,57.33 74.64,57.61 72.73,57.61 71.61,58.73 71.61,59.21 71.36,59.47 71.36,60.15 71.49,60.28 71.49,62.84 75.7,67.06 77.53,67.06
+V1.05DX_MODPHY on BOTTOM (solid shape): 80.1,67.52 80.1,66.63 79.99,66.53 78.62,66.53 78.57,66.58 78.57,67.52 78.62,67.57 80.05,67.57
+V1.05DX_MODPHY on BOTTOM (solid shape): 73.24,56.57 73.24,56.34 73.44,56.14 73.75,56.14 73.82,56.06 73.82,55.81 73.7,55.68 73.26,55.68 73.11,55.53 73.11,55.07 73.19,55 73.19,54.82 73.09,54.72 72.91,54.72 72.35,55.27 72.35,55.73 72.86,56.24 72.86,56.6 72.91,56.65 73.16,56.65
+V1.05DX_MODPHY on IN1 (solid shape): 58.51,64.32 58.51,63.96 58.45,63.9 53.44,63.9 53.44,64.78 53.56,64.9 57.93,64.9
+V1.05DX_MODPHY on IN1 (solid shape): 75.65,56.19 75.65,55.3 75.55,55.2 74.66,55.2 74.51,55.05 74.51,54.67 74.25,54.41 73.59,54.41 73.24,54.77 73.24,56.37 73.37,56.49 75.35,56.49
+V1.05DX_MODPHY on IN1 (solid shape): 95.08,43.97 95.08,43.24 94.96,43.11 94.24,43.11 93.79,42.65 93.25,42.65 92.95,42.96 92.95,43.36 93.35,43.77 93.35,43.97 93.41,44.02 95.03,44.02
+V1.05DX_MODPHY on IN1 (solid shape): 79.33,67.49 79.33,66.48 79.17,66.31 78.15,66.31 78.04,66.43 78.04,66.7 77.94,66.81 75.63,66.81 75.6,66.83 73.16,66.83 71.46,65.13 71.13,65.13 70.95,65.31 70.95,65.61 73.01,67.67 79.16,67.67
+V1.05DX_MODPHY on SVCC (solid shape): 75.46,56.6 75.65,56.41 75.91,56.34 77.22,56.34 77.56,56 77.56,54.82 77.59,54.62 77.7,54.46 84.94,47.22 85.11,47.11 85.3,47.07 95.48,47.07 95.72,46.84 95.72,44.91 95.76,44.72 95.87,44.55 96.48,43.94 96.48,43.6 95.63,42.75 88.94,42.75 88.73,42.84 88.52,42.75 86.42,42.75 85.48,43.69 85.32,43.8 85.12,43.84 79.61,43.84 77.56,45.89 77.52,46.27 77.13,46.31 74.89,48.55 74.89,53.29 74.85,53.49 74.74,53.65 74.07,54.33 73.84,54.46 73.58,54.46 73.11,54.92 73.11,56.24 73.47,56.6
+V1.05DX_MODPHY on IN4 (solid shape): 79.99,66.81 79.99,66.53 79.77,66.3 78.09,66.3 77.84,66.55 77.84,66.88 77.91,66.96 79.84,66.96
+V1.05DX_MODPHY on IN4 (solid shape): 73.62,56.57 73.62,56.09 74.05,55.66 74.61,55.66 74.69,55.58 74.69,55.38 74.58,55.27 73.34,55.27 72.98,55.63 72.98,56.57 73.03,56.62 73.57,56.62
+V1.05S_APLLOPI on TOP (solid shape): 66.08,47.76 66.08,47.58 65.9,47.4 65.9,46.64 65.57,46.31 65.47,46.31 65.32,46.46 65.32,47.74 65.41,47.83 66,47.83
+V1.05S_APLLOPI on TOP (solid shape): 93.96,55.12 93.96,53.67 89.44,53.67 89.14,53.98 89.14,54.88 89.24,54.98 92.53,54.98 92.75,55.2 93.89,55.2
+V1.05S_APLLOPI on IN1 (solid shape): 66.84,50.27 66.84,48.32 66.08,47.55 65.52,47.55 65.41,47.65 65.41,48.11 66.13,48.82 66.13,49.66 66.02,49.76 65.95,49.76 65.85,49.86 65.85,50.22 66,50.37 66.74,50.37
+V1.05S_APLLOPI on IN4 (solid shape): 66.52,50.98 66.52,50.49 66.76,50.25 66.76,49.89 66.63,49.76 65.92,49.76 65.86,49.83 65.86,50.98 66.06,51.18 66.32,51.18
+V1.05S_ASATA3PLL on BOTTOM (solid shape): 76.41,67.49 76.41,66.5 77.15,65.76 80.17,65.76 80.22,65.71 80.22,64.75 80.04,64.57 75.55,64.57 75.14,64.98 75.14,65.31 75.05,65.4 75.05,65.59 75.01,65.63 73.31,65.63 72.91,65.23 72.76,65.23 72.53,65.46 72.53,65.94 72.83,66.25 75.24,66.25 75.24,65.77 75.4,65.61 75.88,65.61 76.06,65.79 76.06,66.22 75.88,66.4 75.4,66.4 75.24,66.25 72.83,66.25 73.26,66.68 74.86,66.68 75.07,66.88 75.07,67.44 75.24,67.62 76.29,67.62
+V1.05S_AUSB3PLL on TOP (solid shape): 59.5,62.94 59.5,61.1 59.37,60.96 58.58,60.96 58.38,61.17 53.58,61.17 53.46,61.28 53.46,62.25 53.53,62.31 58.28,62.31 58.94,62.97 59.47,62.97
+V1.05S_AUSB3PLL on IN2 (solid shape): 59.78,61.12 59.78,60.53 59.62,60.38 58.51,60.38 58.4,60.48 58.4,61.14 58.48,61.22 59.67,61.22
+V1.05S_AXCK_DCB on TOP (solid shape): 88.53,63.4 88.53,59.75 90.18,58.09 93.79,58.09 93.98,57.9 93.98,56.34 93.88,56.24 92.77,56.24 92.14,56.88 89.52,56.88 89.34,57.05 89.34,57.84 87.59,59.59 87.59,63.43 87.77,63.61 88.33,63.61
+V1.05S_AXCK_DCB on TOP (solid shape): outline of 81 points within 73.82,61.19 80.17,64.62
+V1.05S_AXCK_DCB on IN1 (solid shape): 80.63,62.62 80.63,62.13 81.01,61.75 81.01,61.29 80.99,61.27 80.48,61.27 79.82,61.93 79.21,61.93 78.52,62.62 78.52,62.95 78.7,63.12 80.12,63.12
+V1.05S_VCCST on TOP (solid shape): 66.71,49.86 66.71,48.29 66.61,48.19 65.06,48.19 65.01,48.24 65.01,49.86 65.03,49.89 66.68,49.89
+V1.05S_VCCST on BOTTOM (solid shape): 31.66,54.16 31.66,53.22 31.81,53.07 32.06,53.07 32.14,52.99 33.26,52.99 33.49,52.76 33.49,52.33 33.39,52.23 31.73,52.23 31.3,52.66 30.67,52.66 30.62,52.71 30.62,53.4 31.1,53.88 31.1,54.16 31.2,54.26 31.56,54.26
+V1.05S_VCCST on BOTTOM (solid shape): 46.77,67.19 46.77,66.81 46.21,66.25 46.01,66.25 45.7,65.94 45.7,63.91 45.35,63.56 43.06,63.56 42.94,63.68 42.94,63.96 43.62,64.65 45.22,64.65 45.35,64.77 45.35,65.41 45.17,65.59 44.71,65.59 44.64,65.66 44.64,66.35 44.82,66.53 46.09,66.53 46.31,66.76 46.31,67.19 46.39,67.26 46.7,67.26
+V1.05S_VCCST on IN2 (solid shape): 66,49.56 66,48.65 65.95,48.59 64.58,48.59 64.5,48.67 64.5,49.48 64.68,49.66 65.9,49.66
+V1.05S_VCCST on IN4 (solid shape): 65.57,48.75 65.64,48.75 65.75,48.65 65.75,48.32 65.41,47.99 65.31,47.99 64.98,47.65 64.75,47.65 64.55,47.86 64.55,49.36 64.65,49.46 64.86,49.46
+V3.3_THERMAL_R on TOP (solid shape): 173.39,18.83 173.39,17.45 173.21,17.28 173.21,16.29 173.07,16.15 172.04,16.15 171.88,15.98 171.64,15.98 171.64,16.18 171.64,16.77 171.44,16.77 171.44,15.98 171.26,15.98 171.24,16 171.24,17.16 171.59,17.51 171.59,18.83 171.76,19 173.21,19
+V3.3DX_ALS_R on TOP (solid shape): 193.12,25.18 193.99,25.18 194.1,25.29 195.91,25.29 196,25.2 196,23.32 195.65,22.98 193.19,22.98 193.06,23.11 193.06,23.36 192.03,24.39 192.03,25.35 192.19,25.35 192.19,24.69 192.41,24.69 192.41,25.45 192.85,25.45
+V3.3DX_AUDIO on TOP (solid shape): 71.66,39.32 71.66,38.84 71.31,38.49 70.47,38.49 70.22,38.74 70.22,38.99 70.67,39.45 71.54,39.45
+V3.3DX_AUDIO on TOP (solid shape): 185.3,36.16 185.3,35.88 184.95,35.53 184.43,35.53 184.31,35.41 183.71,35.41 183.7,35.43 183.7,35.6 183.71,35.62 183.85,35.62 184.07,35.83 184.07,36.1 184.26,36.29 185.16,36.29
+V3.3DX_AUDIO on TOP (solid shape): 114.04,35.8 114.04,34.88 113.87,34.71 110.05,34.71 110.05,35.01 111.72,35.01 111.97,35.26 111.97,35.82 112.11,35.96 113.88,35.96
+V3.3DX_AUDIO on TOP (solid shape): 102.44,37.51 102.76,37.51 103.84,37.51 103.84,37.21 102.09,37.21 102.04,37.16 101.51,37.16 101.48,37.19 100.97,37.19 100.92,37.24 100.92,37.65 101.05,37.78 102.17,37.78
+V3.3DX_AUDIO on TOP (solid shape): 103.84,36.21 102.63,36.21 101.83,35.4 101.39,35.4 101.2,35.21 101.2,34.83 101,34.62 100.16,34.62 99.3,33.76 98.79,33.76 98.56,33.53 98.56,30.76 98.33,30.54 97.69,30.54 97.54,30.38 97.39,30.38 97.37,30.39 97.31,30.42 97.25,30.43 96.79,30.43 96.63,30.59 96.63,31.15 96.73,31.25 96.76,31.28 96.81,31.3 97,31.97 96.38,31.66 96.35,31.58 96.28,31.55 94.68,31.55 94.59,31.64 94.59,32.68 94.6,32.69 94.6,33 94.73,33.13 96.86,33.13 97.37,33.63 97.37,35.03 97.47,35.13 100.52,35.13 101.05,35.67 101.05,36.05 101.2,36.2 102.12,36.2 102.43,36.51 103.84,36.51
+V3.3DX_AUDIO on IN2 (solid shape): 72.43,39.15 72.43,38.69 72.25,38.51 70.9,38.51 70.65,38.76 70.65,39.17 70.8,39.32 72.25,39.32
+V3.3DX_AUDIO on IN2 (solid shape): 97.85,30.97 97.85,30.28 97.72,30.15 96.4,30.15 96.25,30.31 96.25,30.56 96.35,30.66 96.94,30.66 97.37,31.09 97.72,31.09
+V3.3DX_AUDIO on IN3 (solid shape): 145.01,43.47 145.01,43.32 144.29,42.59 144.07,42.59 143.65,42.17 143.24,42.17 143.11,42.3 143.11,42.91 143.93,43.72 144.76,43.72
+V3.3DX_AUDIO on IN3 (solid shape): 179.16,36.66 179.16,35.01 179.03,34.88 178.01,34.88 177.78,35.11 177.78,35.14 177.78,35.22 177.76,35.31 177.76,35.32 177.76,36.66 177.89,36.78 179.03,36.78
+V3.3DX_AUDIO on IN4 (solid shape): outline of 190 points within 178.39,34.5 185.4,38.69
+V3.3DX_CAMERA on TOP (solid shape): 196.94,50.55 197.42,50.55 197.65,50.78 197.65,51.03 197.83,51.21 198.64,51.21 198.84,51.01 198.84,50.73 198.73,50.61 198.73,50.13 198,49.41 193.74,49.41 193.18,48.85 191.83,48.85 191.78,48.9 191.78,49.81 192.62,50.65 192.62,51.08 192.75,51.21 196.28,51.21
+V3.3DX_CAMERA on BOTTOM (solid shape): 198.98,52.82 198.98,51.67 198.99,51.67 199.22,51.67 199.23,51.68 199.23,52.81 199.26,52.84 199.45,52.84 199.48,52.81 199.48,51.44 198.54,50.5 197.77,50.5 197.67,50.6 197.67,51.11 197.83,51.26 198.36,51.26 198.74,51.64 198.74,52.81 198.76,52.84 198.96,52.84
+V3.3DX_CAMERA_R on TOP (solid shape): 193.24,48.06 193.24,46.83 193,46.59 193,45.37 192.95,45.32 191.5,45.32 191.45,45.37 191.45,46.05 191.42,46.08 191.25,46.08 191.22,46.05 191.22,45.37 191.17,45.32 191.09,45.32 191.04,45.37 191.04,46.36 191.55,46.87 191.55,48.06 191.67,48.18 193.12,48.18
+V3.3DX_NGFF_WLAN on TOP (solid shape): 183.81,24.23 183.81,22.59 184.11,22.29 184.62,22.29 185.64,21.27 185.64,17.79 184.91,17.06 182.31,17.06 181.67,17.7 181.67,17.99 181.83,18.15 182.05,18.15 182.6,17.6 184.59,17.6 185.11,18.12 185.11,21.01 184.46,21.66 183.56,21.66 183.24,21.98 183.24,24.3 183.29,24.35 183.69,24.35
+V3.3DX_NGFF_WLAN on TOP (solid shape): outline of 86 points within 170.43,33.53 180.07,42.37
+V3.3DX_NGFF_WLAN on BOTTOM (solid shape): outline of 203 points within 175.88,15.57 183.8,37.3
