# Allegro board dad13cmbag0-g-roger-165XL.brd (continued)
## Nets (continued)
N127566860: PC208.1 PQ30.1 PQ30.2 PQ30.3 PR211.2
N127567004: PC206.1 PQ26.5 PQ26.6 PQ26.7 PQ26.8 PR210.1
N127567118: PC122.2 PR132.1
N127567146: PR100.1 PU12.11
N127567165: PD4.1 PR119.1

Pads without a net: CN3 6 24 49; CN4 44 46 48 59 61 65 67 71 73; CON1 1 3 5 7 8 10 11 12 13 14 16 17 19 20 22 30 32 36 38 42 43 45 46 47 49; ESD1 4 6; ESD3 4 6; J1 3; J2 2; JBAT1 A1 A2 A3 A4 A5 A6 A7 A8 A9; JKB1 28 29; JP1 6; NOREF#3 1; NOREF#4 1; NOREF#7 1; NOREF#9 1; NOREF#10 1; NOREF#13 1; PU1 21; PU7 6; PU17 1 3 4 27; PU18 5; PU21 4 7; U6 6 7 12 13 14; U10 4 7 20 22 28 32 33 34 35 36 38 39 45 46 47 48; U16 A15 A17 A21 A23 A29 A31 A37 A39 A41 A49 A55 A57 AA23 AA59 AB23 AC2 AC58 AC59 AD23 AD59 AD60 AE59 AE60 AG58 AL1 AM11 AN11 AP7 AP11 AP13 AR10 AR13 AT2 AT10 AU10 AU12 AU15 AU44 AV10 AV44 AV62 AW10 AW14 AY8 AY14 B5 B9 B15 B17 B21 B22 B23 B29 B31 B37 B38 B39 B41 B49 B55 B57 B58 C5 C8 C9 C17 C21 C22 C23 C30 C31 C37 C42 C43 C46 C47 C54 C55 C58 D1 D15 D17 D58 E1 E5 E6 E8 E10 E15 F5 F6 F8 F10 F13 F15 F17 F22 G10 G13 G15 G17 H5 H8 H10 H18 H22 J5 J8 J20 J21 J58 K18 L59 M20 N23 N58 N60 P20 R20 R23 T23 T59 U10 U59 V21 V59 W23 Y4 Y22; U17 1; Y3 2 3

## Via types
v1: diameter 0.254, hole 0.102, IN4 to GND2, 1394 vias
v2: diameter 0.254, hole 0.102, GND2 to BOTTOM, 2268 vias
v3: diameter 0.254, hole 0.102, TOP to GND, 1619 vias
v4: diameter 0.254, hole 0.102, GND to IN1, 859 vias
v5: diameter 0.406, hole 0.203, IN1 to IN4, 690 vias
v6: diameter 0.508, hole 0.254, TOP to BOTTOM, 1153 vias
v7: diameter 0.66, hole 0.33, TOP to BOTTOM, 608 vias
v8: diameter 0.254, hole 0.102, IN3 to IN4, 455 vias
v9: diameter 0.254, hole 0.102, IN1 to IN2, 345 vias
v10: diameter 0.61, hole 0.356, TOP to BOTTOM, 379 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
1.35V_SUS_PWRGD: length 39.4
  TOP w0.127: v4(120.11,55.92) 120.1,55.91 118.55,55.91 117.48,56.98 116.19,56.98 115.91,56.7 v7(115.91,52.61) 115.91,41.58 115.4,41.08 115.4,40.54 115.91,40.03 116.95,40.03 117.41,39.58 118.25,39.58 118.64,39.18 PU10.10
  IN1 w0.089: v4(120.11,55.92) 120.22,55.81 121.84,55.81 125.01,58.97 125.21,58.97 126.97,60.74 128.66,60.74 129.4,61.47 130.79,61.47 131.12,61.8 v4(131.41,61.8)
3.3V_ALW_ON: length 6.8
  TOP w0.127: R42.2 129.75,58.63 v6(130.08,58.96)
  TOP w0.254: Q4.3 129.51,59.4 129.37,59.26
  TOP w0.381: R67.2 128.52,55.21 128.79,55.48 128.79,57.87 129.15,58.23 R42.2 129.15,59.04 129.37,59.26
+0.675V_DDR_VTT: length 53
  TOP w0.508: R430.1 R429.1 ; C526.1 R228.2
  TOP w1.524: 122.72,32.8 122.72,29.93 119.31,26.52 119.31,17.33 117.82,15.83 117.82,10.8 115,7.98 103.79,7.98 103.26,7.45 99.68,7.45 99.04,8.08 92.54,8.08
  vias: v7(25.08,10.57) v7(29.35,19.94) v7(39.58,18.24) v7(48.6,8.62) v7(63.99,8.31) v7(69.86,18.95) v7(90.36,14.38) v7(90.56,7.45)
+1.2V_SWR: length 17.8
  IN3 w0.508: v6(101.81,36.65) 104.27,34.19 108.04,34.19 v6(110.45,31.78) 110.45,33.13 111.01,33.68 111.01,38.05 v6(110.55,38.51)
  vias: v6(103.85,30.18) v6(105.12,17.35) v6(105.12,16.72) v6(111.08,31.78) v7(104.61,18.11)
+1.2V_SWR_L:
  vias: v7(101.64,41.13)
+1.5V_RUN: length 185.4
  TOP w0.127: v7(68.18,58.42) 68.03,58.27 R62.2
  TOP w0.203: PR101.1 191.26,32.88 191.65,32.49 v7(194.85,32.49) 196.89,32.49 197.07,32.68 PC79.1
  IN1 w0.508: 67.75,57.1 67.27,56.62 67.27,54.39 67.8,53.85 67.8,53.12
  IN3 w0.508: 67.78,51.39 67.78,50.07 70.77,47.07 70.77,46.38 71.7,45.46 71.7,45.36 71.84,45.22 71.84,44.09 72.53,43.4 74.34,43.4 75.02,42.72 75.02,40.57 75.67,39.91 77.28,39.91 78.88,38.31 80.43,38.31 80.99,37.75 88.94,37.75 90.64,39.45 92.29,39.45 93.67,38.07 93.67,37.39 96.44,34.62 98.26,34.62 99.45,33.43 107.68,33.43 110.09,31.02 111.18,31.02 111.95,31.78 111.95,33.15 117.94,39.15 120.48,39.15 120.96,38.66 123.89,38.66 124.08,38.47 133.09,38.47 133.77,39.15 137.19,39.15 137.62,39.58 143.01,39.58 145.6,42.17 147.74,42.17 150.81,45.24 153.65,45.24 154.01,44.89 158.73,44.89 160.49,43.13 160.49,41.84 162.32,40.01 165.54,40.01 168.36,37.19 169.73,37.19 171.31,35.62 174.04,35.62 176.53,33.13 177.05,33.13 180.58,29.6 180.58,26.37 181.34,25.61 182.66,25.61 184.01,24.26 191.3,24.26 192.01,24.97 195.12,24.97 204.01,33.86 v6(204.81,33.86)
  vias: v3(67.78,57.74) v3(67.78,57.43) v3(67.78,57.15) v3(68.26,57.74) v3(68.26,57.43) v3(68.26,57.15) v4(67.78,57.74) v4(67.78,57.43) v4(67.78,57.15) v4(68.26,57.74) v4(68.26,57.43) v4(68.26,57.15) v5(67.37,51.8) v5(67.65,52.23) v5(68.01,51.8) v6(204.81,34.5)
+1.05V_RUN: length 55.4
  TOP w0.254: 71.33,56.34 70.93,56.75 70.93,58.3 70.33,58.89 C19.1 69.93,58.89 69.44,59.38 C18.2 ; C96.1 73.14,47.45 72.02,48.57 71.41,48.57 70.7,47.86 C105.2 C104.1 v4(69.17,46.95) C103.2 ; 72.35,55.45 72.35,53.41 C68.1
  TOP w0.508: 51.32,66.53 51.32,65.91 50.73,65.33 v6(50.73,64.72) ; R1.2 39.91,66.7 v7(39.96,66.76) 40.7,67.49 50.51,67.49 50.98,67.02
  IN1 w0.254: v4(73.49,47.45) 73.37,47.45 v5(73.01,47.81)
  IN3 w0.508: v6(50.73,64.72) 50.73,64.43 51.11,64.05 52.58,64.05 53.22,64.7 56.55,64.7 59.09,62.16 64.42,62.16 66.35,60.23 67.7,60.23 68.01,59.92 69.74,59.92 71.61,58.05 71.61,57.76
  IN4 w0.254: v2(71.6,56.49) 72.1,56 v5(72.1,55.91) ; v2(73.31,46.89) 73.39,46.82 v5(73.64,46.82)
  vias: v1(65.41,47.38) v1(66.33,53.48) v1(66.33,52.66) v1(68.3,46.92) v1(69.11,46.92) v1(69.78,57.23) v1(69.92,46.92) v1(70.34,46.72) v1(71.6,57.14) v1(71.87,57.41) v1(71.99,57.1) v1(73.01,54.42) v1(72.98,48.22) v1(73.43,54.42) v1(73.43,47.76) v2(65.41,47.38) v2(66.33,53.48) v2(66.33,52.66) v2(68.3,46.92) v2(69.11,46.92) v2(69.78,57.23) v2(69.92,46.92) v2(70.34,46.72) v2(71.6,57.14) v2(71.87,57.41) v2(71.99,57.1) v2(73.01,54.42) v2(72.98,48.22) v2(73.43,54.42) v2(73.43,47.76) v3(65.41,53.01) v3(65.41,52.66) v3(65.87,52.61) v3(65.87,52.23) v3(65.87,51.85) v3(71.71,55.96) v3(71.71,55.71) v3(73.11,52.66) v3(89.49,61.17) v3(89.49,60.91) v3(89.49,60.66) v3(89.49,60.41) v3(89.49,60.15) v3(89.75,61.17) v3(89.75,60.91) v3(89.75,60.66) v3(89.75,60.41) v3(89.75,60.15) v3(90,61.17) v3(90,60.91) v3(90,60.66) v3(90,60.41) v3(90,60.15) v3(90.26,61.17) v3(90.26,60.91) v3(90.26,60.66) v3(90.26,60.41) v3(90.26,60.15) v4(65.41,53.01) v4(65.41,52.66) v4(65.87,52.61) v4(65.87,52.23) v4(65.87,51.85) v4(71.71,55.96) v4(71.71,55.71) v4(73.11,52.66) v4(89.49,61.17) v4(89.49,60.91) v4(89.49,60.66) v4(89.49,60.41) v4(89.49,60.15) v4(89.75,61.17) v4(89.75,60.91) v4(89.75,60.66) v4(89.75,60.41) v4(89.75,60.15) v4(90,61.17) v4(90,60.91) v4(90,60.66) v4(90,60.41) v4(90,60.15) v4(90.26,61.17) v4(90.26,60.91) v4(90.26,60.66) v4(90.26,60.41) v4(90.26,60.15) v5(65.49,52.15) v5(65.85,47.23) v5(66,53.04) v5(66.25,52.15) v5(68.76,46.9) v5(69.4,46.55) v5(69.56,46.94) v5(69.78,56.9) v5(69.88,46.55) v5(70.19,56.85) v5(71.38,57.51) v5(72.23,54.79) v5(72.56,54.43) v5(72.55,47.81) v5(73.19,53.27) v5(87.74,61.35) v5(87.77,60.91) v5(87.77,60.48) v5(88,60.08) v5(88.17,61.32) v5(88.2,60.89) v5(88.2,60.46) v5(88.2,59.72) v5(88.4,60.08) v5(88.81,60.08) v7(100.42,56.09) v7(100.42,54.82) v8(69.78,57.23) v8(71.6,57.14) v8(71.87,57.41) v8(71.99,57.1)
+1.05V_SUS: length 57.6
  TOP w0.381: R133.1 R134.1 R135.2 ; 101.03,48.62 101.46,49.05 101.46,49.33 102.24,50.12 PC14.1
  TOP w0.508: C122.2 70.53,44.59 ; 70.53,44.59 v6(71.1,45.17) 71.49,44.78 C123.2 ; 70.53,44.59 C121.2
  IN1 w0.508: 37.73,42.65 37.22,42.65 35.52,44.35 v5(35.4,44.35)
  IN3 w0.508: v6(71.1,45.17) 70.7,45.17 69.87,45.99 68.87,45.99 67.86,46.99 66.42,46.99 65.56,46.13 56.27,46.13 55.89,46.51 43.27,46.51 40.5,49.28 36.94,49.28 35.01,47.35 35.01,44.99
  IN4 w0.254: v5(70.14,56.34) 70.5,56.34 v2(70.65,56.49) ; v2(71.99,47.93) v5(71.59,47.93)
  BOTTOM w0.127: v2(73.5,48.71) U16.AD8 ; PC137.1 87.03,65.71 v7(87.03,66.12)
  BOTTOM w0.254: v2(70.74,46.24) 70.84,46.24 71.16,45.93 71.16,45.22 v6(71.1,45.17) ; v2(71.99,47.93) 72.54,48.48 U16.AD10 U16.AD8
  vias: v3(37.6,42.57) v3(38.08,42.57) v3(38.54,42.59) v3(73.48,48.47) v4(37.6,42.57) v4(38.08,42.57) v4(38.54,42.59) v4(73.48,48.47) v5(34.44,44.37) v5(34.89,44.35) v7(98.16,47.78) v9(73.48,48.47) v10(90.89,60.33) v10(90.89,59.59) v10(91.65,60.33) v10(91.65,59.59) v10(92.42,60.33) v10(92.42,59.59) v10(93.18,60.33) v10(93.18,59.59) v10(96.81,46.46) v10(97.14,45.8) v10(97.6,46.44) v10(97.93,45.78) v10(98.33,46.46) v10(98.74,45.83)
+1.8V_RUN: length 165.7
  TOP w0.305: R170.1 172.81,34.63 172.73,34.71 171.88,34.71 171.43,34.27 v6(170.85,34.27)
  TOP w0.508: R64.2 88.76,56.16 88.76,53.42 88.45,53.12 87.76,53.12 87.44,52.79 87.44,52.18 88.17,51.44 88.17,50.09 88.76,49.51 88.76,48.7 89.34,48.11 91.88,48.11 v7(92.42,47.58) 92.97,47.02 ; R181.1 185.1,31.25 v6(185.55,31.7) 185.17,32.08 185.02,32.08 R172.1 185.07,32.75 186.14,32.75 187.11,33.71 187.11,35.82 186.01,36.91 R162.1 184.88,37.38 R159.1 184.21,38.54 184.62,38.94 184.62,39.96 184.24,40.34 180.35,40.34 179.6,41.09 179.6,41.88 179.85,42.13 179.85,43.83 179.28,44.4 178.9,44.4
  IN1 w0.508: 92.82,45.57 92.82,43.82 92.36,43.36 92.36,41.99 91.91,41.53 91.55,41.53 91.3,41.28 91.3,40.21 90.81,39.73 90.81,38.67 v10(89.57,37.43)
  IN2 w0.508: v6(176.92,31.58) 176.95,31.55 176.95,31.48 177.34,31.09 178.89,31.09 179.34,31.54 185.39,31.54 v6(185.55,31.7)
  IN3 w0.508: 176.44,31.93 174.1,34.27 v6(170.85,34.27) 168.36,34.27 167.42,35.21 167.42,37.26 165.38,39.3 161.43,39.3 159.6,41.13 159.6,42.63 157.97,44.25 155.48,44.25 154.67,43.44 153.76,43.44 152.56,44.63 151.11,44.63 147.96,41.48 146.01,41.48 143.42,38.89 138.34,38.89 134.86,35.41 123.05,35.41 120.25,38.21 117.92,38.21 112.63,32.92 112.63,31.6 111.44,30.41 109.84,30.41 107.48,32.77 99.25,32.77 98.03,33.99 95.18,33.99 93.61,35.56 93.61,36.35 92.36,37.6 89.74,37.6 v10(89.57,37.43)
  vias: v3(93.56,46.69) v3(93.91,46.69) v4(93.56,46.69) v4(93.91,46.69) v6(92.54,36.89) v6(176.74,32.19)
+1.8V_SUS: length 181
  IN3 w0.381: 171.71,19.92 171.71,21.24 169.02,23.93 169.02,29.77 169.58,30.33 169.58,30.94
  IN3 w0.762: 153.63,8.72 165.85,8.72 167.27,10.14
  IN4 w0.381: 170.77,19.64 170.77,19.41 166.02,14.66 166.02,12.83 167.83,11.03
  IN4 w0.635: 201.04,37.27 200.3,37.27 199.86,36.83 199.86,27.24 198.69,26.06 198.69,17.84 196.69,15.84 191.77,15.84 190.38,14.46 173.47,14.46 169.62,10.62
  IN4 w0.762: 150.66,8.69 104.96,8.69 104.43,9.22 104.43,11.61 103.85,12.2 103.85,18.8 103.08,19.56 103.08,21.42 101.69,22.81 101.69,30.43 100.64,31.48 99.43,31.48
  BOTTOM w0.203: 174.65,11.64 174.66,11.65 174.66,13.62 174.97,13.92 181.06,13.92 181.32,14.18 186.01,14.18 186.95,13.24 187.34,13.24 PC210.1 PR215.1
  BOTTOM w0.381: Q32.2 169.38,30.27 169.38,30.84
  vias: v1(98.38,31.96) v1(98.38,31.7) v1(98.64,31.96) v1(98.64,31.7) v1(98.89,31.96) v1(98.89,31.7) v1(169.63,30.97) v1(169.81,31.27) v2(98.38,31.96) v2(98.38,31.7) v2(98.64,31.96) v2(98.64,31.7) v2(98.89,31.96) v2(98.89,31.7) v2(169.63,30.97) v2(169.81,31.27) v6(167.65,10.62) v6(168.31,10.62) v6(201.76,37.55) v6(201.76,36.78) v7(169.53,8.92) v7(170.01,10.88) v7(198.87,38.54) v8(151.67,8.77) v8(151.67,8.41) v8(152.05,8.77) v8(152.05,8.41) v8(152.41,8.77) v8(152.41,8.41) v8(169.63,30.97) v8(169.81,31.27) v8(171.03,19.64) v8(171.41,19.61)
+3.3V_ALW: length 364.5
  TOP w0.127: R6.2 140.47,66.13 v6(139.66,66.13) ; R73.1 146.29,54.18 v6(148.17,52.3)
  TOP w0.203: R21.1 126.01,63.67 126.12,63.78 v9(126.12,64.85) ; v6(5.29,9.48) 5.9,8.87 PR148.1
  TOP w0.254: SJ2.1 138.01,26.62 v7(138.03,26.6) 138.26,26.37 v10(139.41,26.37) ; 132.98,66.35 132.98,66.45 132.57,66.86 130.11,66.86 129.96,66.7 v4(129.96,66.68)
  TOP w0.305: 125.56,47.45 125.94,47.07 126.68,47.07 127.33,47.72 130.22,47.72 130.54,48.04 130.54,50.45 129.63,51.36 126.5,51.36 126.22,51.64 126.22,53.79 R72.1 ; v4(120.61,60.69) 120.61,58.54 R47.2
  TOP w0.381: R123.1 80.03,45.29 80.9,44.42 ; PR134.1 110.58,14.73 110.25,15.06 109.99,15.06 109.56,15.49 109.56,16.26 109.99,16.69 ; 80.9,44.42 82.27,44.42 82.39,44.55 82.55,44.71 85.3,44.71 v6(86.14,43.87) ; 80.9,44.42 80.9,43.03 80.32,42.45 80.32,38.87 82.13,37.06 R165.1 ; PR133.2 108.55,14.6 v6(108.13,15.02)
  TOP w0.508: v6(190.54,21.16) 190.33,20.96 R223.1 ; v6(109.56,17.63) 109.56,17.12 109.99,16.69 ESD2.5 ; v10(120.63,47.64) 119.15,47.64 118.45,48.34 R89.1 ; R471.1 v6(104.23,19.51) ; EC25.1 195.79,18.51 v6(195.85,18.45) ; v6(131.94,14.18) 131.96,14.15 131.96,12.7 PR142.1 ; v6(166.89,53.93) 166.89,54.74 172.94,60.8 RT1.1
  IN1 w0.254: v4(129.96,66.68) 128.13,64.85 v9(126.12,64.85) 124.91,64.85 122.87,62.81 122.87,62.34 122.51,61.98 122.14,61.98 120.99,60.84 120.76,60.84 v4(120.61,60.69)
  IN1 w0.508: v6(190.54,21.16) 192.95,21.16 193.48,21.7 195.29,21.7 195.59,22 ; 97.7,23.32 97.37,23.32 96.99,23.7 96.99,28.22 97.62,28.86
  IN2 w0.127: v9(130.9,59.53) 130.84,59.47 129.66,59.47 129.51,59.31 128.48,59.31 127.87,59.92 127.87,63.1 v9(126.12,64.85)
  IN2 w0.381: 98.26,22.56 98.21,22.61
  IN2 w0.508: 98.26,22.56 98.26,21.42 100.16,19.51 v6(104.23,19.51) 107.68,19.51 v6(109.56,17.63)
  IN3 w0.203: v6(5.29,9.48) 5.29,7.6 5.85,7.04 9.69,7.04 11.57,8.92 13.01,8.92 13.85,8.08 19.14,8.08 20.58,6.63 22.67,6.63 22.97,6.94 26.78,6.94 27.16,7.32 42.33,7.32 42.76,6.89 49.02,6.89 50.66,8.53 54.02,8.53 55.15,7.4 63.41,7.4 64.02,6.79 70.16,6.79 70.63,7.26 71.02,7.26 71.51,6.76 73.14,6.76 73.59,7.22 75.65,7.22 76.16,6.71 82.36,6.71 82.86,7.22 84.87,7.22 85.18,6.91 87.23,6.91 87.74,7.42 88.4,7.42 89.06,6.76 91.88,6.76 94.9,9.78 96.35,9.78 97.01,9.12 99.2,9.12 100.29,10.22 100.29,16.39 103.05,19.14 103.86,19.14 v6(104.23,19.51)
  IN3 w0.381: v5(121.65,40.67) 120.96,41.36 105.32,41.36 104.74,41.94 103.74,41.94 103.73,41.94 97.29,41.94 96.83,41.48 91.55,41.48 89.65,43.39 89.65,43.84 89.34,44.15 86.42,44.15 v6(86.14,43.87)
  IN3 w0.508: v6(108.13,15.02) 108.13,16.21 v6(109.56,17.63) 110.2,17 110.2,15.32 110.83,14.69 119.72,14.69 123.05,18.01 125.64,18.01 129.12,14.53 131.58,14.53 v6(131.94,14.18) ; 167.22,48.52 167.22,53.6 v6(166.89,53.93) 156.35,53.93 155.56,54.72 150.58,54.72 v6(148.17,52.3)
  BOTTOM w0.203: PC198.1 PC199.1 150.18,22.7 PU20.1 152.12,22.7 152.36,22.94 152.36,24.85 152.89,25.38 153.15,25.38 v6(154.01,26.24)
  BOTTOM w0.508: v6(148.17,52.3) 137.33,63.14 v6(137.33,64.82) 137.33,64.84 v7(138.01,65.51) 138.63,66.13 v6(139.66,66.13) ; CN6.2 v6(195.85,18.45) ; v6(154.01,26.24) 154.01,25.6 PR208.1
  vias: v3(97.67,29.42) v3(98.03,29.42) v3(98.08,29.09) v4(97.67,29.42) v4(98.03,29.42) v4(98.08,29.09) v5(167.42,47.25) v5(167.9,47.27) v5(168.36,47.45) v5(186.01,38.69) v5(186.01,38.18) v5(186.52,38.69) v5(186.52,38.18) v6(163.92,15.57) v6(163.92,14.94) v6(173.57,12.91) v6(174.08,13.42) v6(188.35,28.1) v6(188.35,27.46) v6(188.57,43.06) v6(192.08,43.39) v6(193.01,27.67) v9(97.67,22.97) v9(98,22.97) v9(98.31,22.97) v10(121.37,47.64) v10(124.89,48.49) v10(125.63,48.49) v10(133.43,26.1) v10(133.97,26.6) v10(134.6,27.11) v10(134.63,25.61) v10(134.63,24.87) v10(134.68,26.35) v10(135.3,27.5) v10(135.32,26.75) v10(135.33,26) v10(135.33,25.26) v10(164.12,35.39) v10(164.37,36.12) v10(164.91,35.62) v10(168.08,35.62) v10(168.69,36.03) v10(168.77,35.3)
+3.3V_ALW_AVCC: length 10.5
  TOP w0.127: L2.1 145.6,55.78 v7(146.03,55.35) ; U4.E9 v9(139.01,57.93)
  TOP w0.381: v6(144.87,58.12) 145.26,57.73 C45.1 145.26,57.22 145.6,56.88 L2.1
  IN2 w0.508: 138.82,58.86 138.82,59.24 139.18,59.59 143.39,59.59 v6(144.87,58.12)
+3.3V_DEEP_SLEEP_OFF: length 243.2
  TOP w0.508: 81.75,33.23 81.75,32.01 80.43,30.69 Q9.3 78.19,30.69 78.17,30.71 R177.2 ; 46.72,35.03 54.44,35.03 55.05,34.42 61.99,34.42 63.71,36.15 63.71,43.51 64.48,44.28 65.49,44.28 ; R48.1 147.41,58.9 v6(146.99,59.31)
  IN1 w0.508: 45.68,35.26 34.48,35.26 29.68,40.06 27.7,40.06 25.66,38.03 25.66,36.86 24.14,35.33 22.77,35.33 20.61,33.18 17.97,33.18 16.01,31.22 14.79,31.22 13.8,32.21 10.64,32.21 v6(9.1,30.68) ; 80.58,48.32 80.2,48.7 76.9,48.7 76.59,49 75.88,49 ; 68.11,44.58 67.8,44.28 66.43,44.28 ; 68.11,44.58 68.11,44.51 68.42,44.2 71.92,44.2 72.21,43.91 72.21,43.65 72.48,43.39 73.31,43.39 ; 68.11,44.58 68.11,45.8 ; 73.8,42.47 72.65,41.33 72.65,40.64 74.23,39.07 76.92,39.07 78.95,37.04 78.95,36.86 80.65,35.16 81.21,35.16 81.75,34.62
  IN2 w0.508: v6(67.52,48.59) 70.95,52.02 72.43,52.02 72.93,51.52 72.93,50.4
  IN3 w0.508: 157.41,42.42 157.75,42.08 157.75,40.38 160.18,37.95 164.8,37.95 166.18,36.57 166.18,36.34 166.18,31.28 v6(167.21,30.25) ; v6(146.99,59.31) 145.07,59.31 143.27,57.51 141.01,57.51 140.37,56.88 135.47,56.88 132.34,53.75 130.34,53.75 129.63,54.46 122.39,54.46 122.35,54.43 118.26,54.43 116.11,52.28 115.35,52.28 114.87,52.76 v2(114.87,52.99) ; 86.14,46.59 88.3,46.59 88.76,47.05 89.39,47.05 89.77,46.66 ; v6(91.53,43.2) 92.64,42.09 96.43,42.09 96.96,42.63 103.82,42.63 103.96,42.48 105.08,42.48 105.57,41.99
  BOTTOM w0.254: Q28.2 Q28.5 ; R328.2 84.23,45.55 84.84,46.16 85.58,46.16 85.83,46.41 R325.2 85.28,47.2 84.8,47.2 84.29,46.69 R322.2 ; R317.2 v2(83.79,47.4) ; U16.AC9 v2(72.98,50.14)
  BOTTOM w0.305: 9.37,31.93 9.9,32.46 CN3.27
  BOTTOM w0.508: R342.2 90.12,41.36 v6(90.62,40.85) 90.12,40.34 R347.2 R350.2 ; v6(9.1,30.68) 9.37,30.94 EC62.1 9.37,31.93 ; 156.7,43.06 156.7,43.87 153.96,46.61 153.96,52.35 v6(146.99,59.31) ; v6(67.52,48.59) 67.24,48.59 U16.AE20 66.43,47.79 U16.AE21 ; 106.74,42.09 107.02,41.81 111.97,41.81 114.87,44.71 v2(114.87,52.99) ; R369.1 167.21,30.68 v6(167.21,30.25)
  vias: v1(71.55,46.24) v1(85.84,46.66) v1(89.88,46.66) v1(90.21,46.66) v1(90.36,46.28) v1(105.75,42.37) v1(106,42.37) v1(156.55,42.5) v1(156.93,42.5) v2(71.55,46.24) v2(85.84,46.66) v2(89.88,46.66) v2(90.21,46.66) v2(90.36,46.28) v2(105.75,42.37) v2(106,42.37) v2(156.55,42.5) v2(156.93,42.5) v3(46.31,35.36) v3(46.31,35.08) v3(65.59,44.28) v3(65.97,44.28) v3(73.57,43.16) v3(73.8,42.91) v3(73.82,42.63) v3(74.99,49.48) v3(75.27,49.48) v3(80.66,48.29) v3(81.24,47.96) v3(81.87,34.24) v3(81.87,33.86) v3(83.04,46.94) v4(46.31,35.36) v4(46.31,35.08) v4(65.59,44.28) v4(65.97,44.28) v4(73.57,43.16) v4(73.8,42.91) v4(73.82,42.63) v4(74.99,49.48) v4(75.27,49.48) v4(80.66,48.29) v4(81.24,47.96) v4(81.87,34.24) v4(81.87,33.86) v4(83.04,46.94) v5(73.95,50.19) v5(74.46,50.19) v5(83.42,47.27) v7(91.25,45.22) v8(85.84,46.66) v8(89.88,46.66) v8(90.21,46.66) v8(90.36,46.28) v8(105.75,42.37) v8(106,42.37) v8(156.55,42.5) v8(156.93,42.5) v9(68.16,46.36) v9(68.16,46.05)
+3.3V_DSW: length 10.4
  TOP w0.127: v7(79.05,46.28) 78.47,45.7 R123.2
  TOP w0.381: v6(72.88,46.66) 73.02,46.79 74.86,46.79 75.07,46.59 75.07,46.18 75.55,45.7 75.55,45.14 75.93,44.76 76.57,44.76 77.18,44.14 C119.2 77.31,44.15 R128.2 R123.2
  BOTTOM w0.254: v6(72.88,46.66) 72.46,46.24 U16.AH10
+3.3V_EC: length 71.2
  TOP w0.254: v9(143.14,54.54) 143.14,54.59 142.68,55.05 142.68,55.91 143.11,56.34 v9(144.13,56.34)
  IN1 w0.254: v9(140.14,55.22) v4(139.89,55.48)
  IN2 w0.254: v5(132.16,54.71) 132.41,54.46 134.1,54.46 134.86,55.23 v9(135.75,55.23) ; v9(140.14,55.22) 141.92,55.22 142.61,54.54 v9(143.14,54.54) ; v9(144.13,56.34) 143.42,56.34 142.05,57.71 140.63,57.71 139.91,58.43 v9(139.91,58.48)
  IN3 w0.508: v5(136.08,58.07) 135.53,58.07 v5(132.16,54.71) 131.36,55.5 129.02,55.5 128.58,55.07 122.06,55.07 122.02,55.04 117.76,55.04 v2(115.71,52.99)
  BOTTOM w0.508: Q29.2 95.34,41.1 95.6,40.84 R344.1 96.78,40.84 97.41,41.47 100.98,41.47 101.48,40.97 103.85,40.97 v7(104.25,40.57) 104.86,40.57 105.47,41.18 112.89,41.18 115.71,44 v2(115.71,52.99)
  vias: v3(136.51,58.48) v3(136.51,57.98) v3(136.76,58.77) v4(136.51,58.48) v4(136.51,57.98) v4(136.76,58.77) v5(136.08,58.65) v5(136.84,58.08) v6(135.72,62.13) v6(135.72,61.5) v9(136.51,58.48) v9(136.51,57.98) v9(136.76,58.77)
+3.3V_EN2: length 35
  TOP w0.127: R75.1 127.32,54.19 127.56,54.43 R67.1 128.54,53.99 v6(128.54,53.8) ; v6(154.37,44.1) 154.37,44.25 v7(153.78,44.84) 153.68,44.94 PQ7.2
  BOTTOM w0.127: v6(154.37,44.1) 154.04,43.77 147.3,43.77 136.59,54.49 129.22,54.49 v6(128.54,53.8)
+3.3V_RTC_LDO: length 235.5
  TOP w0.508: R42.1 128.21,58.47 v6(128.21,55.82) ; v6(207.35,33.48) 206.56,33.48 Q30.3 206.33,33.1 v7(205.09,31.86) 203.29,30.05 202.02,30.05 D18.1 ; R472.1 103.97,20.53 v6(104.25,20.25) ; PR26.1 129.68,53.55 128.75,52.62 128.68,52.62 128.67,52.61 v6(128.56,52.61)
  IN1 w0.508: v6(163.94,12.78) 163.43,12.78 162.59,13.62 162.59,17.97 163.31,18.68 v6(163.31,21.82)
  IN2 w0.508: 124.34,59.32 125.94,59.32 128.21,57.04 v6(128.21,55.82) ; v6(207.35,33.48) 210.35,30.48 210.35,25.71 208.77,24.13 208.77,20.92 v6(209.51,20.18)
  IN3 w0.508: v6(163.94,12.78) 152.36,12.78 147.66,8.08 104.23,8.08 101.05,11.26 101.05,15.45 103.72,18.11 104.3,18.11 105.12,18.93 105.12,19.69 104.56,20.25 v6(104.25,20.25)
  IN4 w0.508: v6(163.31,21.82) 163.05,21.82 162.56,22.31 162.56,26.73 160.27,29.02 159.92,29.02 157.03,31.91 157.03,32.82 156.3,33.56 156.3,34.12 155.87,34.54 v6(155.1,34.54) ; v6(209.51,20.18) 209.51,19.89 208.23,18.62 205.56,18.62 203.54,16.6 200.56,16.6 196.08,12.12 174.66,12.12 170.75,8.21 166.41,8.21 163.94,10.67 v6(163.94,12.78)
  BOTTOM w0.508: v6(155.1,34.54) 155.23,34.66 155.23,35.31 152.99,37.55 152.99,41.64 152.08,42.55 147.15,42.55 136.27,53.43 129.41,53.43 128.59,52.61 v6(128.56,52.61) 128.2,52.61 127.39,53.41 127.39,54.99 v6(128.21,55.82)
  vias: v3(123.65,58.74) v3(123.88,58.96) v4(123.65,58.74) v4(123.88,58.96) v9(123.65,58.74) v9(123.88,58.96)
+3.3V_RUN: length 313.4
  TOP w0.127: 91.95,39.33 v4(91.78,39.33)
  TOP w0.254: v9(130.03,65.05) 129.94,65.05 R13.1 ; v6(204.07,53.85) 203.51,53.29 R81.1 ; PR47.1 104.4,43.18 104.99,42.6 v4(104.99,40.97) ; U1.5 157.99,61.56 v6(158.35,61.93)
  TOP w0.305: RP5.4 145.94,52.08 v6(146.16,52.3) 146.16,52.56 145.99,52.73 RP5.2 ; C140.1 91.95,39.33 91.94,39.34 U9.5
  TOP w0.381: v6(86.45,59.97) 86.62,59.97 88.71,57.89 R60.2 ; 84.92,56.85 84.55,57.22 R44.1
  TOP w0.508: R12.1 v6(202.52,66.12) ; U5.5 U5.4 187.92,58.05 187.97,58 C44.1 v6(189.44,58) ; PR27.2 27.49,54.34 27.01,54.82 v7(27.01,54.94) 26.96,55 26.96,60.08 26.22,60.81 24.77,60.81 v6(24.39,60.43) ; v6(169.76,29.42) 169.76,31.23 R176.2 ; PC35.1 162.78,44.15 163.13,44.15 163.36,43.92 163.94,43.92 164.34,44.32 164.34,46.51 165.29,47.46 165.29,48.16 v6(164.22,49.23) ; v6(178.76,29.12) 178.37,29.51 R185.2 ; R220.1 172.8,21.23 174.23,22.66 175.9,22.66 176.36,22.2 v6(176.36,21.92)
  IN1 w0.254: v10(128.47,48.49) 128.48,48.49 128.46,48.46 128.46,46.21 127.14,44.89 121.9,44.89 120.74,43.72 116.39,43.72 115.68,44.43 114.54,44.43 114.07,43.97 114.07,41.32 112.53,39.78 108.09,39.78 107.25,40.62 106.05,40.62 105.93,40.49 ; v5(136.53,54.84) 136.79,55.1 137.04,55.1 137.25,55.3 137.25,55.74 137.01,55.98 v4(137.01,55.98) ; v5(92.03,40.92) 92.03,39.59 v4(91.78,39.33)
  IN1 w0.508: 73.72,59.47 72.27,59.47 71.49,58.68 70.47,58.68 70.42,58.63 ; v6(24.39,60.43) 24.39,60.58 31.3,67.49 48.5,67.49 v6(49.13,66.85)
  IN1 w1.016: 184.06,31.7 183.78,31.98 183.78,34.8 183.35,35.23 183.35,36.76 184.87,38.28 v5(184.87,41.89) 184.87,46.59 183.6,47.86 183.6,48.98
  IN2 w0.254: v9(130.03,65.05) 128.71,63.73 v5(128.71,59.96)
  IN2 w0.381: v6(24.39,60.43) 23.15,61.68 17.92,61.68 17.36,61.12 17.36,51.95 18.27,51.03 20.13,51.03 21.35,49.81 21.35,44.28 20.38,43.31 v6(20.38,41.64)
  IN3 w0.254: v5(92.03,40.92) 97.14,40.92 97.67,41.46 103.64,41.46 103.7,41.52 104.56,41.52 106.24,39.84 v5(106.28,39.84)
  IN3 w0.508: 95.67,58.07 96.1,57.64 108.77,57.64 110.55,55.86 121.85,55.86 125.89,59.9 128,59.9 ; 178.39,28.4 177.63,27.64 177.63,24.97 176.04,23.39 176.04,22.24 v6(176.36,21.92) ; v6(86.45,59.97) 87.53,58.89 87.72,58.89 88.03,58.58 91.93,58.58 92.29,58.93 93.89,58.93 94.37,58.45 94.37,58.35 ; 68.36,58.81 65.67,58.81 64.75,59.72 58.35,59.72 54.9,63.17 50.38,63.17 v6(50.02,63.53) ; 178.39,29.29 178.27,29.42 v6(169.76,29.42)
  IN4 w0.508: v6(49.13,66.85) 49.13,66.3 50.02,65.41 v6(50.02,63.53) ; v5(184.87,41.89) 183.63,43.13 v2(182.97,43.13) v2(182.08,43.13) v2(181.32,43.13) v2(180.68,43.13)
  BOTTOM w0.203: R302.2 85.42,51.13 85.99,51.13 86.17,51.31 86.17,51.95 85.94,52.18 85.94,52.41 R292.2
  BOTTOM w0.254: R270.2 84.01,56.72 84.54,56.72 84.72,56.9 85.63,56.9 85.82,56.71 R276.2 86.12,56.39 86.19,56.47 86.19,56.65 86.57,57.03 86.65,57.03 87.24,57.61 88.36,57.61 ; 88.36,57.61 R273.1 ; 88.36,57.61 R267.2 R269.2 ; 83.66,52.18 R295.2 ; 83.66,52.18 R291.2 ; 83.66,52.18 83.69,52.15 85.18,52.15 R292.2 ; R286.2 86.08,54.17 86.27,53.98 87.41,53.98 87.77,54.34 v6(87.77,54.51) ; 87.59,54.82 87.18,55.22 86.27,55.22 86.12,55.38 R280.2 85.34,54.89 84.34,54.89 84.18,55.06 83.93,55.06 R281.2
  BOTTOM w0.381: R266.1 85.57,59.56 85.28,59.85 84.12,59.85 R265.2 ; R266.1 R277.2 ; R266.1 85.73,59.26 v6(86.45,59.97) 86.45,60.2 86.93,60.69 87.59,60.69 88.22,60.05 88.22,59.27 R269.2
  BOTTOM w0.508: v6(184.69,49.18) 184.69,49.31 R305.2 ; R459.1 97.12,56.6 96.73,56.21 95.34,56.21 ; 177.2,44.01 177.77,43.44 179.36,43.44 R477.2 ; R345.1 21.3,40.72 v6(20.38,41.64)
  vias: v1(85.79,52.61) v1(88.7,52.38) v1(88.99,52.38) v1(94.78,58.4) v1(95.06,58.4) v1(95.34,58.4) v2(85.79,52.61) v2(88.7,52.38) v2(88.99,52.38) v2(94.78,58.4) v2(95.06,58.4) v2(95.34,58.4) v3(68.79,58.65) v3(69.17,58.65) v3(69.56,58.65) v3(74.5,59.57) v3(74.86,59.57) v3(75.21,59.57) v4(68.79,58.65) v4(69.17,58.65) v4(69.56,58.65) v4(74.5,59.57) v4(74.86,59.57) v4(75.21,59.57) v5(69,58.35) v5(69.43,58.32) v5(129.14,59.96) v6(88.1,53.95) v6(178.81,28.48) v6(180.45,56.77) v6(181.09,56.77) v6(184.62,30.54) v6(185.26,30.54) v6(204.05,54.94) v7(126.45,48.92) v8(85.79,52.61) v8(88.7,52.38) v8(88.99,52.38) v8(94.78,58.4) v8(95.06,58.4) v8(95.34,58.4) v10(127.73,48.49) v10(129.21,48.49) v10(129.94,48.49)
+3.3V_RUN_DPF1:
  vias: v7(206.13,56.8)
+3.3V_RUN_ON_P: length 5.3
  TOP w0.127: PU3.5 123.52,47.53 123.89,47.17 123.9,47.17 124.17,46.9 PC29.1 PR42.1 PR230.2 126.32,46.32 126.72,46.72 v7(127.24,46.72)
+3.3V_SUS: length 202.4
  TOP w0.254: R476.2 79.06,42.72 79.06,42.65 78.91,42.5 78.35,42.5 78.34,42.51 77.78,42.51 77.31,42.99 R131.2 ; v9(72.25,51.31) 72.48,51.54 R90.2 ; 94.07,45.19 92.31,45.19 91.91,45.6 88.81,45.6 87.59,46.82 86.14,46.82 85.95,47 R115.2 R114.2
  TOP w0.381: 66.04,31.76 65.64,31.36 53.9,31.36 53.21,32.05 45.06,32.05 42.43,34.68 31.05,34.68 27.77,37.95 27.73,37.95 v6(27.69,37.99)
  TOP w0.508: C525.1 66.56,44.83 66.56,43.72 R130.1 65.29,43.06 64.88,42.65 v7(64.88,41.25) 64.63,41 64.63,38.23 66.83,36.03 66.83,32.54 66.04,31.76 66.17,31.76 67.75,30.18 70.07,30.18 70.32,30.43 70.32,30.68 R182.1 70.8,30.84 71.46,30.18 75.75,30.18 76.24,30.66 76.24,31.35 R177.1 77.61,32.72 Q9.1 79.74,33.89 79.74,36.04 80.28,36.58 v6(80.28,37.29) 80.28,37.95 79.74,38.49 79.74,42.61 R476.2 79.94,43.61 R128.1
  IN1 w0.381: v6(13.75,29.85) 14.68,29.85 15.14,29.39 22.57,29.39 27.69,34.51 v6(27.69,37.99)
  IN2 w0.254: v6(80.28,37.29) 78.91,38.66 75.8,38.66 74.56,39.91 74.56,41.56 74.74,41.74 74.74,42.27 74.33,42.68 74.08,42.68 73.37,43.39 72.6,43.39 71.59,44.4 70.85,44.4 70.34,44.91 70.34,49.41 v9(72.25,51.31)
  IN3 w0.508: 92.72,34.27 92.72,36.12 92.14,36.71 82.99,36.71 82.74,36.96 80.91,36.96 80.58,37.29 v6(80.28,37.29) ; 119.81,53.4 v10(119.81,53.39)
  IN3 w0.635: 101.31,54.44 102.07,53.67 105.17,53.67 105.95,52.89 113.47,52.89 114.89,51.46 116.49,51.46 118.42,53.4 119.81,53.4
  BOTTOM w0.254: R297.1 98.5,51.52 97.75,52.28 97.75,53.12 98.21,53.57 98.21,54.67 ; 93.79,46.82 93.33,47.27 92.77,47.27 92.52,47.53 90.19,47.53 R318.2 ; 92.52,45.29 93.17,44.64 R332.2
  BOTTOM w0.381: 101.08,46.28 102.47,47.68 110.04,47.68 110.58,48.21 R312.1
  BOTTOM w0.508: 92.06,45.01 92.06,43.74 92.66,43.14 92.66,40.96 R348.2 ; R473.1 13.29,30.31 v6(13.75,29.85)
  vias: v1(92.14,45.5) v1(92.44,45.5) v1(93.1,39.09) v1(93.42,39.09) v1(93.76,46.56) v1(93.76,39.09) v1(94.02,46.56) v1(99.27,46.56) v1(99.27,46.31) v1(99.65,46.56) v1(99.65,46.31) v1(99.91,54.69) v1(100.04,46.56) v1(100.04,46.31) v1(100.16,54.69) v1(100.42,54.69) v1(100.42,46.56) v1(100.42,46.31) v1(100.67,54.69) v2(92.14,45.5) v2(92.44,45.5) v2(93.1,39.09) v2(93.42,39.09) v2(93.76,46.56) v2(93.76,39.09) v2(94.02,46.56) v2(99.27,46.56) v2(99.27,46.31) v2(99.65,46.56) v2(99.65,46.31) v2(99.91,54.69) v2(100.04,46.56) v2(100.04,46.31) v2(100.16,54.69) v2(100.42,54.69) v2(100.42,46.56) v2(100.42,46.31) v2(100.67,54.69) v3(104.2,42.3) v3(104.2,41.91) v4(104.2,42.3) v4(104.2,41.91) v5(104.35,43.29) v6(94.35,45.06) v6(94.98,45.06) v6(121.68,51.46) v7(97.62,55.33) v8(92.14,45.5) v8(92.44,45.5) v8(93.05,34.37) v8(93.05,34.12) v8(93.05,33.86) v8(93.76,46.56) v8(94.02,46.56) v8(99.27,46.56) v8(99.27,46.31) v8(99.65,46.56) v8(99.65,46.31) v8(99.91,54.69) v8(100.04,46.56) v8(100.04,46.31) v8(100.16,54.69) v8(100.42,54.69) v8(100.42,46.56) v8(100.42,46.31) v8(100.67,54.69) v10(120.58,53.39)
+3.3V_SUS_ON_P: length 5.3
  TOP w0.127: PU3.3 122.72,47.04 PC27.1 PR41.1 PR40.2 118.95,46.32 v7(118.81,46.46)
+3.3V_THERMAL: length 235
  TOP w0.254: 14.53,42.44 14.58,42.44 14.74,42.29 14.74,41.93 14.56,41.75 U8.1 ; Q16.5 Q16.2 175.24,20.63
  TOP w0.381: R137.1 16.63,42.91 v6(15.99,43.55) 15.95,43.59 14.84,43.59 14.53,43.28 R136.1 ; R136.1 C126.1 ; R136.1 14.53,42.44
  IN1 w0.381: v6(174.18,49) 173.85,48.67 173.85,41.23 175.45,39.63 175.45,22.36 175.55,22.25
  IN3 w0.381: v6(15.99,43.55) 16.31,43.87 20.69,43.87 22.15,45.33 29.36,45.33 29.55,45.14 31.91,45.14 33.72,46.94 33.72,47.65 36.54,50.47 40.62,50.47 41.01,50.86 41.01,51.54 41.39,51.92 42.4,51.92 42.65,52.18 42.65,57.22 45.68,60.25 45.68,63.05 48.19,65.56 56.65,65.56 59.45,62.77 65.29,62.77 67.19,60.86 68.03,60.86 68.39,60.51 69.93,60.51 71.23,59.21 75.65,59.21 76.67,60.23 76.67,62.16 77.5,63 79.78,63 82.35,60.42 85.07,60.42 87,62.36 87,62.82 88.91,64.72 91.02,64.72 93.18,66.88 101.94,66.88 104.48,64.34 107.91,64.34 109.18,63.07 109.18,59.26 111.67,56.77 121.47,56.77 126.17,61.47 130.39,61.47 131.35,60.51 134.76,60.51 134.8,60.46 145.7,60.46 145.83,60.33 148.8,60.33 149.26,60.79 150.15,60.79 155.15,55.78 157.01,55.78 157.87,54.92 160.79,54.92 161.1,54.61 167.7,54.61 168.03,54.28 168.03,52.07 168.82,51.29 170.79,51.29 171.71,50.36 173.05,50.36 174.18,49.23 v6(174.18,49)
  vias: v3(175.24,22.1) v3(175.24,21.72) v3(175.63,22.1) v3(175.63,21.72) v4(175.24,22.1) v4(175.24,21.72) v4(175.63,22.1) v4(175.63,21.72) v7(174.61,21.59)
+3.3V_TPM: length 21.8
  TOP w0.305: 154.37,47.72 U6.10 U6.19 154.37,56.44 154.7,56.78 155.35,56.78 C42.1 ; 151.12,47.98 U6.5 U6.24 151.12,56.85 150.73,57.23
  TOP w0.381: C41.2 150.45,57.51 150.73,57.23
  vias: v7(155.53,44.94)
+5V_ALW: length 268.9
  TOP w0.127: v7(222.59,26.5) R206.1
  TOP w0.152: PU16.4 170.54,13.45 170.54,13.44
  TOP w0.178: PU14.4 191.31,27.88 v6(191.78,28.35) 191.92,28.49 PC91.1 ; v6(190.28,42.42) 190.33,42.47 PU5.4
  TOP w0.191: PU9.4 166.31,35.61 167.09,34.83 PC78.1 ; PC22.1 v4(99.65,47.84) PU2.4
  TOP w0.203: v6(163.94,25.18) 164.09,25.33 SJ4.1 ; v6(164.6,25.18) 165.16,25.74 SJ3.1 ; PC46.1 190.33,42.37 v6(190.28,42.42)
  TOP w0.254: v4(162.67,47.25) 162.67,47.21 162.14,46.68 PU4.4 ; 196.17,45.67 195.87,45.37 195.26,45.37 194.77,44.88 R125.1
  TOP w0.381: PC129.1 170.62,12.45 170.27,12.81 v6(170.27,13.03) 170.27,13.17 170.54,13.44 ; 115.28,48.06 115.28,41.64 115,41.36 115,40.31 115.28,40.03 PR82.2 PR83.1 ; 115.18,49.5 115.18,53.74 110.83,58.1 110.83,58.87 111.16,59.2 v6(111.16,59.62) ; PC78.1 166.85,34.48 166.51,34.14 166.51,32.8 165.82,32.11 165.82,22.53 v10(165.9,22.46)
  TOP w0.508: v6(196.85,18.45) 196.94,18.54 EC26.1 ; R147.2 200.61,40.97 201,41.36 v6(201,41.74) ; R206.1 222.58,25.48 221.96,25.48 221.7,25.23 221.7,23.37 222.59,22.48 R217.1 222.22,21.93 221.83,21.54 221.83,19.66 222.59,18.9 R229.1 222.43,18.22 222.18,18.22 221.96,17.99 221.96,16.24 222.46,15.73 R241.1 222.3,15.04 222.05,15.04 221.83,14.82 221.83,13.3 R243.1 221.69,12.63 v6(221.92,12.41) ; v6(202.02,41.74) 203.24,41.74 203.93,42.43 R129.1 204.43,43.64 204.68,43.39 206.46,43.39 206.97,43.9 206.97,44.66 207.35,45.04 ESD1.5 ; 99.04,26.55 99.67,25.92 99.67,23.27 101.12,21.82 v6(101.61,21.82)
  IN1 w0.254: v4(99.65,47.84) 99.79,47.71 103.31,47.71 104.72,49.11 112.46,49.11 112.89,49.53 114.88,49.53 v4(115.21,49.2)
  IN1 w0.508: 158.07,47.91 154.72,47.91 152.99,46.18 152.99,44.02 152.49,43.51 151.85,43.51 151.19,44.18 151.19,44.68 150.53,45.34 150,45.34 ; 162.47,46.97 162.47,46.69 161.53,45.75 161.53,42.04 166.02,37.55 166.02,25 v10(167.31,23.72)
  IN2 w0.381: v9(201,49.1) 201,48.8 v5(201.2,48.59)
  IN3 w0.381: v6(190.28,42.42) 190.28,42.19 192.75,39.73 v6(193.02,39.73)
  IN3 w0.508: v10(201.21,23.73) 204.04,20.91 213.95,20.91 221.92,12.94 v6(221.92,12.41) ; v6(111.16,59.62) 111.16,59.06 112.84,57.38 120.3,57.38 125.82,62.89 130.16,62.89 131.58,61.47 132.72,61.47 134.17,62.92 146.34,62.92 147.74,61.52 151.44,61.52 152.97,60 158.15,60 162.06,56.09
  IN4 w0.508: v6(101.61,21.82) 102.17,21.26 102.17,18.26 102.8,17.63 102.8,17.61 103.06,17.35 103.06,11.87 103.62,11.31 103.62,8.67 105.29,6.99 115.91,6.99
  BOTTOM w0.381: v6(140.42,11) 139.02,12.4 v7(139.02,13.54) 139.02,16.55 140.06,17.59 ESD3.5
  BOTTOM w0.508: PR168.1 110.75,61.35 111.16,60.94 v6(111.16,59.62) ; CN6.1 v6(196.85,18.45)
  vias: v3(148.3,45.93) v3(148.3,45.67) v3(148.3,45.42) v3(148.3,45.17) v3(157.97,48.14) v3(157.97,47.76) v3(158.35,48.14) v3(158.35,47.76) v3(162.21,47.63) v3(162.21,47.25) v3(162.67,47.63) v4(148.3,45.93) v4(148.3,45.67) v4(148.3,45.42) v4(148.3,45.17) v4(157.97,48.14) v4(157.97,47.76) v4(158.35,48.14) v4(158.35,47.76) v4(162.21,47.63) v4(162.21,47.25) v4(162.67,47.63) v5(116.24,6.96) v5(116.88,6.96) v6(162.52,56.09) v6(163.15,56.09) v6(168.69,13.53) v6(169.38,13.54) v7(187,10.62) v10(18.2,31.01) v10(18.83,30.52) v10(18.93,31.27) v10(19.64,31.83) v10(19.64,31.07) v10(165.9,21.72) v10(166.63,22.48) v10(166.63,21.75) v10(167.32,22.94) v10(181.67,8.46) v10(182.08,7.8) v10(182.41,8.46) v10(196.43,48.57) v10(197.16,48.57) v10(197.9,48.57) v10(198.28,47.93) v10(200.45,23.74) v10(200.97,17.42) v10(201.71,17.38)
+5V_ALW2: length 379.6
  TOP w0.191: PU15.4 200.25,20.38 ; PU3.4 123.12,46.34
  TOP w0.203: PU7.14 151.77,36.73 151.57,36.53 ; 151.57,36.53 151.57,36.3 153.38,34.5 PC76.2 ; 151.57,36.53 151.37,36.73 PU7.13 ; 123.12,46.34 PC28.1
  TOP w0.254: 200.25,20.38 v6(200.01,20.14) ; PC76.2 154.01,34.5 154.49,34.98 v6(154.54,34.98) ; PC28.1 123.39,46.32 123.68,46.61 v4(123.68,46.92)
  TOP w0.381: RTCR1.1 v9(204.18,36.78) ; v4(6.16,22.31) 6.16,25.35 7.45,26.65 7.45,30.74 7.91,31.2 7.91,34.19 8.24,34.52 8.24,44.48 9.69,45.93 24.35,45.93 R407.1 ; PC113.1 199.24,20.14 v6(200.01,20.14) ; v4(147.99,47.26) 147.6,47.65 147.33,47.65 v7(147.05,47.93) 146.8,48.19 PR31.1 ; v9(118.2,19.51) 118.2,17.78 117.18,16.77 R409.1 ; PR136.1 2.69,14.09 2.96,13.82 2.96,12.88 3.36,12.48 5.14,12.48 5.32,12.65 v4(6.23,12.65)
  TOP w0.508: PR222.1 6.18,15.7 7.07,14.81 v4(8.62,14.81) 9.79,14.81 10.58,15.6 16.04,15.6 16.6,15.04 22.05,15.04 28.75,21.74 38.06,21.74 39.41,20.4 45.96,20.4 46.49,19.87 57.87,19.87 59.93,21.92 85.33,21.92 87.18,20.07 95.29,20.07 96.61,18.75 100.29,18.75 100.59,18.44 v6(103.11,18.44)
  IN1 w0.254: v5(123.94,47.53) 123.94,47.17 v4(123.68,46.92)
  IN1 w0.381: v5(133.8,44.98) 133.8,44.14 135.01,42.93 135.01,38.89 135.6,38.31 135.6,29.93 132.55,26.88 130.39,26.88 v9(129.63,26.12) ; v5(150.53,49.43) 149.73,49.43 147.99,47.7 v4(147.99,47.26) 147.99,46.51 147.84,46.35 147.84,44.99 148.27,44.56 148.68,44.56 152.56,40.67 152.56,37.19 154.54,35.21 v6(154.54,34.98)
  IN1 w0.508: v6(164.07,13.52) 163.73,13.52 163.24,14 163.24,17.7 164.05,18.5 164.05,22.1 163.69,22.46 v6(163.33,22.46) ; v4(8.62,14.81) 8.39,14.81 v4(6.23,12.65) 5.42,12.65 5.04,13.03 5.04,15.45 6.61,17.02 6.61,21.85 v4(6.16,22.31)
  IN2 w0.381: v6(200.01,20.14) 200.01,21.5 199.6,21.91 199.6,27.26 204.18,31.83 v9(204.18,36.78) ; v9(129.63,26.12) 129.12,25.61 128.81,25.61 124.47,21.26 121.34,21.26 119.59,19.51 v9(118.2,19.51) 111.95,19.51 110.73,18.29 110.73,17.48 109.71,16.46 107.4,16.46 105.42,18.44 v6(103.11,18.44)
  IN3 w0.508: v5(123.94,47.53) 125.08,46.38 131.56,46.38 132.97,44.98 v5(133.8,44.98) 134.35,45.53 134.35,46 135.86,47.5 137.92,47.5 139.54,45.88 140.5,45.88 143.98,49.36 148.5,49.36 148.73,49.59
  IN4 w0.508: v6(164.07,13.52) 164.93,12.65 164.93,10.88 166.76,9.05 170.72,9.05 174.41,12.73 195.68,12.73 200.01,17.07 v6(200.01,20.14) ; v6(163.33,22.46) 163.33,27.39 163.05,27.67 163.05,28.66 162.01,29.7 160.56,29.7 157.71,32.55 157.71,33.14 157.21,33.63 157.21,34.37 156.29,35.29 154.86,35.29 v6(154.54,34.98)
  vias: v5(151.14,49.43) v5(151.72,49.43)
+5V_FAN: length 164.4
  TOP w0.762: v10(21.04,35.46) 21.45,35.46 25.59,31.32 41.65,31.32 43.91,29.06 51.66,29.06 52.28,28.44 59.01,28.44 60.56,26.88 88.17,26.88 89.7,25.35 90.84,25.35 93.34,22.85 97.25,22.85 97.88,22.23 v10(99.53,22.23)
  IN2 w0.762: v10(99.53,22.23) 100.11,22.81 102.17,22.81 102.75,22.23 120.02,22.23 120.46,22.66 123.17,22.66 128.03,27.51 131.91,27.51 133.56,29.16 137.12,29.16 137.75,28.53 137.75,25.35 140.5,22.61 140.5,18.34 145.96,12.88 156.5,12.88 160.23,16.62 163.05,16.62 163.66,17.23
  vias: v6(163.92,17.48) v6(163.92,16.84) v7(163.92,19.33)
+5V_FAN_R:
  vias: v7(168.06,16.82)
+5V_PTC: length 32.6
  TOP w0.203: PR219.1 153.18,23.82 v6(153.46,23.54)
  IN1 w0.254: v5(143.87,41.87) 143.57,42.17 v4(143.57,42.19)
  IN4 w0.254: v5(143.87,41.87) 143.87,40.09 147.61,36.35 151.39,36.35 152.63,35.12 152.63,33.39 153.2,32.82 153.2,30.56 151.75,29.11 151.75,26.42 152.66,25.51 154.85,25.51 155.33,25.02 155.33,24.02 v2(154.89,23.58)
  BOTTOM w0.254: v6(153.46,23.54) PU20.5 154.24,22.7 154.39,22.55 154.88,22.55 PC201.1 v2(154.89,23.58)
  vias: v7(140.52,44.58)
+5V_RUN: length 460
  TOP w0.254: Q15.1 163.59,21.04 164.57,20.05 v6(165.98,20.05)
  TOP w0.305: v10(174.69,63.58) 174.33,63.94 174.33,65.03 172.93,66.43 v7(170.01,66.43) 167.22,66.43 165.59,64.8 159.8,64.8 158.79,63.79 R22.2 160.72,63.2 161.22,62.69 161.22,59.82 161.6,59.44 161.6,57.08 159.14,54.61 159.14,49.76 158.48,49.1 157.87,49.1 157.37,48.6 R111.2 ; U3.8 202.48,55.52 202.63,55.38 203.62,55.38 203.79,55.55 C54.1 ; R164.2 157.2,35.33 157.49,35.62 161.6,35.62 162.43,34.79 162.43,25.67 163.89,24.21 163.89,22.81 165.8,20.91 166.2,20.91
  TOP w0.508: v6(30.46,57.41) 30.46,58.7 29.93,59.24 PR19.2 ; PC13.1 16.21,51.63 v6(15.71,51.13)
  IN1 w0.254: 198.64,56.34 197.41,56.34 196.63,57.12 196.63,60.23 196.17,60.69 v4(196.17,64.71) 204.69,64.71 v4(204.91,64.5)
  IN1 w0.381: 202.14,55.83 202.04,55.73 202.04,53.73 203.26,52.51 203.26,50.17 202.3,49.2 202.3,43.49 203.41,42.37 203.41,37.13 v6(202.89,36.61) ; 202.14,55.83 199.4,55.83 199.2,56.04 ; 202.14,55.83 202.27,55.96
  IN1 w0.508: v10(193.13,14.18) 193.13,16.21 189.6,19.74 189.6,21.42 188.76,22.25 188.76,25.28 187.13,26.9 186.24,26.9 182.82,30.33 182.82,33.94 182.36,34.4 182.36,37.42 183.78,38.84 v10(183.78,39.2) 183.78,45.78 178.11,51.44 178.11,56.85 176.06,58.9 176.06,62.2 v10(174.69,63.58) ; v6(119.49,64.42) 109.69,64.42 109,65.1 104,65.1 102.73,66.37 94.02,66.37 91.96,64.32 89.32,64.32 88.83,64.8 87.28,64.8 85.51,66.58 82.48,66.58 80.52,64.61 77.45,64.61 77.01,65.05 73.81,65.05 72.85,64.09 66.2,64.09 64.24,62.13 52.44,62.13 51.37,63.2 51.37,65.1 51.04,65.43 42.57,65.43 40.29,63.14 38.79,63.14 37.37,61.72 37.27,61.52 37.27,59.69 34.99,57.41 v6(30.46,57.41)
  IN2 w0.508: 193.46,35.64 194.62,35.64 195.08,36.1 202.38,36.1 v6(202.89,36.61) ; 191.6,35.64 189.62,37.62 185.35,37.62 184.52,38.46 184.31,38.46 183.78,38.99 v10(183.78,39.2)
  IN2 w0.762: v6(165.98,20.05) v6(166.72,20.05) 169.47,20.05 171.41,18.11 171.41,17.86 173.82,15.45 174.61,15.45 177.78,12.27
  IN2 w2.032: 103.95,8.84 169.76,8.84 170.9,9.99 178.65,9.99
  IN3 w0.508: v6(119.49,64.42) 119.49,64.42 130.03,64.42 131.53,65.92 137.65,65.92 138.74,64.83 173.44,64.83 v10(174.69,63.58) ; v6(15.71,51.13) 20.53,51.13 20.79,51.39 20.79,53.17 22.39,54.77 24.95,54.77 25.51,54.21 28.31,54.21 30.46,56.37 v6(30.46,57.41)
  vias: v3(191.98,35.64) v3(192.57,35.67) v3(192.95,35.64) v3(199.04,56.93) v3(199.04,56.62) v3(199.05,56.29) v3(202.5,56.72) v3(202.5,56.42) v3(202.51,56.03) v4(191.98,35.64) v4(192.57,35.67) v4(192.95,35.64) v4(199.04,56.93) v4(199.04,56.62) v4(199.05,56.29) v4(202.5,56.72) v4(202.5,56.42) v4(202.51,56.03) v6(98.33,24.97) v6(98.33,24.34) v6(98.97,24.97) v6(98.97,24.34) v6(100.54,8.84) v6(101.18,8.84) v6(101.81,8.84) v6(102.45,8.84) v7(205.19,16.9) v9(191.98,35.64) v9(192.57,35.67) v9(192.95,35.64) v10(206.97,19.51) v10(207.35,20.15) v10(207.86,19.51)
+5V_RUN_ON_P: length 5.2
  TOP w0.127: PR128.2 198.98,16.48 v7(198.99,16.46)
  TOP w0.191: PU15.5 200.55,19.98
  TOP w0.203: PR128.2 PR125.1 PC115.1 199.96,19.38 200.55,19.98
+5V_SUS: length 140.4
  IN3 w0.508: v8(147.86,20.83) 150.12,20.83 152.56,18.39 162.29,18.39 163,19.11 169.28,19.11 169.76,18.62 174.79,18.62 176.57,20.4 181.24,20.4 184.03,23.19 189.6,23.19 189.87,23.47 196.26,23.47 198.7,25.91 203.74,25.91 204.68,24.97 206.13,24.97 v10(207.15,23.96)
  IN4 w0.508: v8(147.86,20.83) 147.46,21.24 147.46,26.06 147.86,26.47 147.86,28.48 147.38,28.96 146.06,28.96 144.97,30.05 144.97,35.51 143.39,37.09 134.68,37.09 134.07,37.7 125.66,37.7 124.85,36.89 120.96,36.89 120.05,35.97 117.38,35.97 116.34,34.93 113.37,34.93 112.61,34.17 105.75,34.17 104.15,32.57 97.27,32.57 96.76,32.06 v6(96.76,31.68)
  BOTTOM w0.254: v6(96.76,31.68) 96.73,31.68 v6(96.28,32.14) 96.04,32.37 94.49,32.37 94.22,32.64 94.22,33.66 94.01,33.87 PC178.1 93.69,33.9 93.69,34.22 94.02,34.55 94.93,34.55 95.19,34.81 PU19.4
  vias: v7(202.91,22.81)
+5V_SUS_ON_P: length 5.2
  TOP w0.127: PR120.2 198.98,24.27 v7(199.04,24.34)
  TOP w0.191: PU15.3 200.14,20.78
  TOP w0.203: PR120.2 PR123.1 PC111.1 199.5,21.42 200.14,20.78
+15V_ALW: length 78.5
  TOP w0.127: v7(128.84,11.08) PD7.1
  TOP w0.254: PD7.1 130.41,11.92 v6(130.9,12.4) ; PR37.1 113.69,47.38 v6(113.69,48.79) 112.09,48.79 PQ4.1 ; v6(140.01,46.54) 140.62,45.93 PR44.1
  IN3 w0.254: v6(140.01,46.54) 140.01,46.56 140.02,46.57 140.02,46.7 138.32,48.39 135.67,48.39 134.62,47.34 124.99,47.34 123.94,48.39 123,48.39 121.37,46.77 115.43,46.77 113.69,48.51 v6(113.69,48.79)
  IN4 w0.254: v6(130.9,12.4) 131.66,12.4 133.18,13.92 133.18,17.12 131.61,18.69 131.61,25.94 135.54,29.87 135.54,34.78 135.62,34.85
  BOTTOM w0.254: v6(140.01,46.54) v6(140.01,41.97) 140.01,41.43 135.75,37.16 135.75,36.02
  vias: v1(135.6,35.64) v1(135.6,35.26) v2(135.6,35.64) v2(135.6,35.26) v7(137.7,43.67)
+DVDD-25-LDO-O:
  vias: v7(115.22,33.33)
+V1.05A_AOSCSUS: length 30.4
  TOP w0.254: C86.2 72.53,49.48 v4(72.25,49.76)
  TOP w0.381: C80.1 89.49,49.61 88.78,50.32 88.78,51.82 88.53,52.07 88.53,52.43
  IN1 w0.381: 72.1,50.55 71.28,51.36 71.28,56.16 71.51,56.39 71.87,56.39 72.95,57.48 75.76,57.48 78.78,54.46 79.31,54.46 79.92,53.85 86.43,53.85 87.31,52.96 87.51,52.96
  IN4 w0.254: v5(72.25,50.14) 72.73,49.66 v2(73.43,49.66)
  vias: v3(87.94,52.58) v3(88.3,52.58) v4(87.94,52.58) v4(88.3,52.58) v7(93.94,48.21)
+V1.05DX_MODPHY: length 21.1
  TOP w0.381: 99.22,41.03 100.47,41.03 101.72,42.28 101.72,42.94 102.45,43.67 v7(102.45,44.28) 102.45,45.41 102.31,45.55 PR39.1
  IN1 w0.508: 57.82,64.19 63.54,64.19 64.77,65.43 71.38,65.43
  vias: v1(73.11,56.49) v1(73.11,56.24) v1(73.09,55.83) v1(73.44,55.83) v1(73.7,55.83) v1(78.95,66.82) v1(79.28,66.82) v1(79.61,66.81) v2(73.11,56.49) v2(73.11,56.24) v2(73.09,55.83) v2(73.44,55.83) v2(73.7,55.83) v2(78.95,66.82) v2(79.28,66.82) v2(79.61,66.81) v3(53.68,64.34) v3(53.68,64.01) v3(54.19,64.34) v3(54.19,64.01) v3(54.7,64.34) v3(54.7,64.01) v3(73.9,55.94) v3(73.87,54.92) v3(73.87,54.56) v3(74.3,55.07) v3(74.38,55.96) v3(75.8,66.93) v3(76.16,66.93) v3(76.49,66.93) v3(76.82,66.93) v3(77.15,66.93) v3(77.48,66.93) v3(93.58,43.9) v3(93.58,43.64) v3(93.96,43.9) v3(93.96,43.64) v3(94.22,43.9) v3(94.22,43.64) v3(94.47,43.9) v3(94.47,43.64) v3(94.85,43.9) v3(94.85,43.64) v4(53.68,64.34) v4(53.68,64.01) v4(54.19,64.34) v4(54.19,64.01) v4(54.7,64.34) v4(54.7,64.01) v4(73.9,55.94) v4(73.87,54.92) v4(73.87,54.56) v4(74.3,55.07) v4(74.38,55.96) v4(75.8,66.93) v4(76.16,66.93) v4(76.49,66.93) v4(76.82,66.93) v4(77.15,66.93) v4(77.48,66.93) v4(93.58,43.9) v4(93.58,43.64) v4(93.96,43.9) v4(93.96,43.64) v4(94.22,43.9) v4(94.22,43.64) v4(94.47,43.9) v4(94.47,43.64) v4(94.85,43.9) v4(94.85,43.64) v5(73.44,56.27) v5(73.9,55.48) v5(74.38,55.48) v5(78.32,66.5) v5(78.78,66.5) v5(93.13,43.26) v5(93.38,42.91) v5(93.56,43.27) v5(93.99,43.27) v5(94.42,43.27) v5(94.85,43.27) v7(72.63,62.26)
+V1.05S_APLLOPI: length 31
  TOP w0.508: 65.59,46.72 65.34,46.46 C112.1
  IN1 w0.508: 89.27,54.56 88.61,55.22 87.41,55.22 86.58,54.39 80.17,54.39 79.59,54.97 79.57,54.97 79.54,55.01 79,55.01 75.97,58.04 72.73,58.04 71.64,56.95 71.26,56.95 70.72,56.42 70.72,53.07 67.75,50.09 66.68,50.09
  vias: v1(66.33,51.04) v1(66.33,50.25) v2(66.33,51.04) v2(66.33,50.25) v3(65.59,47.68) v3(65.97,47.68) v3(89.37,54.74) v3(89.37,54.31) v3(89.75,54.74) v3(89.75,54.31) v4(65.59,47.68) v4(65.97,47.68) v4(89.37,54.74) v4(89.37,54.31) v4(89.75,54.74) v4(89.75,54.31) v5(66.05,49.97) v5(66.56,49.97) v7(92.42,54.56)
+V1.05S_ASATA3PLL: length 6.9
  BOTTOM w0.254: U16.B11 71.62,61.07 72.1,61.55 72.1,62.29 72.5,62.69
  BOTTOM w0.508: 72.5,62.69 72.81,63 74.18,63 75.65,64.47 C236.1
  vias: v6(72.81,65.56)
+V1.05S_AUSB3PLL: length 12.7
  TOP w0.508: v6(67.8,62.18) 67.8,62.08 v7(67.27,61.55) 67.15,61.43 C17.1
  IN2 w0.508: 59.57,60.79 59.85,60.51 66.13,60.51 v6(67.8,62.18)
  BOTTOM w0.254: v6(67.8,62.18) 67.8,61.48 67.39,61.07 U16.B18
  vias: v3(58.63,61.09) v3(59.01,61.09) v3(59.4,61.09) v4(58.63,61.09) v4(59.01,61.09) v4(59.4,61.09) v9(58.63,61.09) v9(59.01,61.09) v9(59.4,61.09)
+V1.05S_AXCK_DCB: length 21.8
  IN1 w0.508: v5(66.39,57.09) 66.39,56.71 v4(66.63,56.47) ; 80.76,61.55 82.05,60.25 85.76,60.25 87.08,61.58 87.08,62.67 87.82,63.4 87.89,63.4
  IN2 w0.508: 73.49,61.98 73.14,61.98 72.76,61.6 71.89,61.6 70.72,60.43 70.72,58.53 69.81,57.61 66.91,57.61 v5(66.39,57.09)
  IN3 w0.508: v5(66.39,57.09) 66.96,56.52 v2(67.37,56.52)
  vias: v3(74,61.98) v3(74.3,61.98) v3(74.61,62.08) v3(79.05,62.79) v3(79.44,62.79) v3(79.77,62.79) v3(88.05,63.43) v3(88.05,63.17) v3(88.27,63.3) v4(74,61.98) v4(74.3,61.98) v4(74.61,62.08) v4(79.05,62.79) v4(79.44,62.79) v4(79.77,62.79) v4(88.05,63.43) v4(88.05,63.17) v4(88.27,63.3) v7(88.35,59.39) v9(74,61.98) v9(74.3,61.98) v9(74.61,62.08)
+V1.05S_AXCK_LCPLL: length 21.2
  TOP w0.508: L9.2 C2.1 55.93,65.23 C1.1 57.59,64.39 58.13,64.39 59.06,63.45 60.54,63.45 60.92,63.07 v7(63.59,63.07) 66.2,63.07 66.71,62.56 v6(66.71,62.18) 65.11,60.58 C40.1 65.09,59.38 R35.2
  BOTTOM w0.254: U16.A20 66.49,61.97 v6(66.71,62.18)
+V1.05S_VCCST: length 64.6
  TOP w0.508: v6(31.4,53.93) 31.4,54.68 34.08,57.36 37.8,57.36 R45.2 38.31,59.38 38.31,62.06 v7(39.58,63.33) 42.61,63.33 v6(43.16,63.89)
  IN2 w0.508: v6(43.16,63.89) 43.16,61.29 45.83,58.63 57.67,58.63 57.79,58.75 64.48,58.75 65.26,57.97 65.26,55.17 64.76,54.67 64.76,49.38
  IN3 w0.508: v6(31.4,53.93) 29.27,51.8 28.33,51.8 28,52.13 25.51,52.13 25.13,51.74 v6(25.13,51.39)
  BOTTOM w0.254: v2(65.62,48.59) 65.41,48.81 U16.AC22
  BOTTOM w0.508: v6(31.4,53.93) 31.4,54.43 31.66,54.68 R282.1 ; v6(25.13,51.39) 25.13,51.69 25.45,52.01 PR188.2
  vias: v1(64.9,47.79) v1(65.41,48.19) v2(64.9,47.79) v2(65.41,48.19) v3(65.49,48.98) v3(65.56,49.37) v3(65.86,49.53) v3(65.85,49.1) v4(65.49,48.98) v4(65.56,49.37) v4(65.86,49.53) v4(65.85,49.1) v5(64.75,49.23) v5(64.76,48.8) v9(65.49,48.98) v9(65.56,49.37) v9(65.86,49.53) v9(65.85,49.1)
+V3.3_THERMAL_R:
  vias: v6(171.87,18.85)
+V3.3DX_1.5DX_AUDIO: length 6.2
  TOP w0.508: v6(69.34,45.35) 69.29,45.3 68.95,45.3 68.54,44.89 C120.2 68.54,44.59 68.04,44.59 67.78,44.33 67.6,44.33 v6(67.29,44.02) 67.29,43.13 R130.2 R462.2
  BOTTOM w0.508: v6(69.34,45.35) 69.34,45.74 69.79,46.19 69.87,46.19 U16.AH14
+V3.3DX_ALS: length 72.6
  TOP w0.381: C71.1 198.55,51.69 198.64,51.69 199.02,51.31 199.54,51.31 v6(199.94,50.92)
  TOP w0.508: v6(196.24,30.82) 196.09,30.67 196.08,30.67 v7(195.56,30.15) 195.41,30 195.41,26.76 R201.2
  IN3 w0.508: v2(173.75,46.31) 174.86,45.19 v6(181.16,45.19) 181.73,44.62 184.75,44.62 190.1,39.27 190.1,37.77 191.75,36.12 191.75,32.08 193.02,30.82 v6(196.24,30.82)
  IN4 w0.508: v6(196.24,30.82) 196.24,35.27 199.88,38.92 199.88,42.47 201.03,43.62 201.03,47.71 199.63,49.1 199.63,50.61 v6(199.94,50.92)
  BOTTOM w0.254: v2(173.75,46.31) Q26.5 Q26.2 ; RP32.3 RP32.1 175.73,46.65 176.23,46.65 177.21,45.67 Q27.5 Q27.2 180.44,45.67 180.92,45.19 v6(181.16,45.19) ; v6(199.94,50.92) 199.85,51 J1.6
+V3.3DX_ALS_R:
  vias: v7(195.46,23.4)
+V3.3DX_AUDIO: length 304.8
  TOP w0.508: 70.55,38.74 70.24,38.74 69.35,37.85 67.35,37.85 65.43,39.77 65.43,40.43 65.9,40.9 R462.1 ; v6(14.21,25.43) 14.41,25.23 14.41,24.35 15.47,23.27 38.73,23.27 40.07,21.92 46.97,21.92 47.51,21.39 57.24,21.39 59.29,23.45 85.96,23.45 87.81,21.59 96.99,21.59 97.52,21.06 101.84,21.06 102.37,21.59 102.37,22.14 101.93,22.59 101.44,22.59 100.43,23.59 100.43,26.24 100.42,26.25 100.42,27.5 100.54,27.61 100.54,29.19 99.35,30.38 98.69,30.38 98.32,30.76
  IN1 w0.508: v6(9.23,29.93) 9.23,29.29 13.11,25.43 v6(14.21,25.43)
  IN2 w0.508: 72.2,38.84 76.34,34.7 76.49,34.7 76.54,34.66 79.38,34.66 83.63,30.4 97.05,30.4
  IN3 w0.508: v6(100.04,34.88) 100.04,36.07 101.38,37.42 v6(101.81,37.42) 103.11,38.71 104.71,38.71 105.24,38.18 106.13,38.18 108.26,40.31 111.87,40.31 ; 111.87,40.31 111.87,35.83 v6(112.63,35.07) ; 111.87,40.31 114.87,40.31 115.12,40.57 120.69,40.57 121.42,39.83 122.92,39.83 124.47,41.38 129.7,41.38 130.77,40.31 136.13,40.31 137.14,41.33 141.69,41.33 142.66,42.3 143.42,42.3 ; 178.14,36.53 177.89,36.78 176.95,36.78 175.63,38.1 168.82,38.1 166.13,40.8 162.67,40.8 161.38,42.09 161.38,43.64 159.37,45.65 154.72,45.65 154.37,46 146.92,46 144.46,43.54 ; v2(117.18,50.98) 116.8,50.6 114.59,50.6 113.34,51.85 105.55,51.85 104.76,52.63 100.57,52.63 98.4,54.81 94.53,54.81
  BOTTOM w0.203: Q24.5 91.93,55.45 91.63,55.15 91.25,55.15 90.94,55.45 Q24.2
  BOTTOM w0.254: v2(93.46,54.81) 93.46,55.25 93.25,55.45 Q24.5
  BOTTOM w0.305: 10.4,31.67 CN3.26
  BOTTOM w0.508: v2(117.18,50.98) 117.74,50.42 117.74,42.68 112.63,37.57 v6(112.63,35.07) ; v6(9.23,29.93) 9.98,29.93 R465.1 10.36,31.64 10.4,31.67 ; v6(100.04,34.88) 100.67,34.88 101.13,35.34 102.5,35.34 103.16,36 106.77,36 108.01,37.23 R463.2
  vias: v3(70.9,39.12) v3(71.1,38.84) v3(71.31,39.12) v3(97.19,30.74) v3(97.52,30.92) v3(97.52,30.56) v4(70.9,39.12) v4(71.1,38.84) v4(71.31,39.12) v4(97.19,30.74) v4(97.52,30.92) v4(97.52,30.56) v6(184.39,36.06) v6(185.06,36.01) v7(96.91,32.59) v8(178.52,35.89) v8(178.52,35.51) v8(178.52,35.13) v8(178.9,35.89) v8(178.9,35.51) v8(178.9,35.13) v9(70.9,39.12) v9(71.1,38.84) v9(71.31,39.12) v9(97.19,30.74) v9(97.52,30.92) v9(97.52,30.56)
