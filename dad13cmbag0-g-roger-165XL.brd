# Allegro board dad13cmbag0-g-roger-165XL.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+V3.3DX_AUDIO_IO: length 4.3
  BOTTOM w0.305: CN3.25 10.9,32.27 11.25,31.92
  BOTTOM w0.508: 11.25,31.92 EC65.1 11.25,30.96 11.14,30.85 R465.2 R473.2
+V3.3DX_CAMERA:
  vias: v6(197.95,50.92) v6(198.59,50.92) v7(194.02,50.27)
+V3.3DX_CAMERA_R: length 1.4
  TOP w0.127: v7(193.86,47.63) 193.79,47.7 PR34.1
+V3.3DX_NGFF_WLAN: length 7.5
  TOP w0.508: R484.1 172.17,25.36 172.18,25.36 172.56,25.74 R485.1 R486.1 176.24,27 v6(176.36,26.88) ; v6(178.67,24.67) 178.34,24.67 177.64,23.97 R200.2
  vias: v6(176.95,35.21) v6(176.95,34.52) v6(176.95,33.89) v6(181.95,17.85) v7(177.76,15.84)
+V3.3DX_NGFF_WLAN_R:
  vias: v7(169.35,39.32)
+V3.3DX_SSD: length 17.3
  BOTTOM w1.524: 161.16,48.74 161.16,56.43 161.83,57.1 161.83,59.01 161.71,59.14
  BOTTOM w2.032: 161.33,48.32 161.33,46.56 163.48,44.4 163.48,42.68
  vias: v6(160.11,61.04) v6(160.74,36.71) v6(162.27,42.78) v6(162.7,42.3) v6(163.36,42.04) v6(164.04,42.04) v7(160.59,41.28)
+V3.3DX_SSD_R:
  vias: v7(163.92,38.1)
+V3.3DX_TCH_PAD: length 163.4
  TOP w0.508: v6(187.09,21.85) 187.09,22.06 187.58,22.55 R214.2
  IN1 w0.508: v6(187.09,21.85) 186.7,22.24 186.7,25.81 186.22,26.29 185.91,26.29 182.95,29.26 181.65,29.26 180.68,30.22 180.68,37.8 181.9,39.02 v5(182.59,39.02)
  IN3 w0.254: v5(182.59,39.02) 182.59,40.09 179.05,43.62 168.51,43.62 168.11,44.02 167.4,44.02 165.54,45.88 165.54,48.67 163.74,50.47 159.83,50.47 159.5,50.8 148.14,50.8 147.76,50.42 141.51,50.42 141.01,49.92 133.13,49.92 132.29,50.75 120.2,50.75 118.83,49.38 116.32,49.38 115.99,49.71 114.51,49.71 113.29,50.93 105.13,50.93 104.14,51.92 100.09,51.92 98.51,53.5 94.55,53.5 93.86,54.19 93.23,54.19 93.11,54.31 92.75,54.31 92.39,53.95 92.39,53.12 v2(91.65,52.38)
  BOTTOM w0.254: 91.65,52.89 91.37,53.17 Q25.5 ; 91.65,52.89 v2(91.65,52.38) ; 91.65,52.89 91.93,53.17 Q25.2
  BOTTOM w0.508: 160.11,12.91 161.45,14.25 169.83,14.25 170.37,14.79 180.65,14.79 180.93,15.07 186.29,15.07 187.09,15.86 v6(187.09,21.85)
  vias: v6(157.62,20.27) v6(157.62,19.64) v7(157.82,10.11)
+V3.3DX_TCH_PAD_R:
  vias: v7(188.2,25.53)
+V3.3DX_TCH_SCR: length 90.6
  TOP w0.508: v6(186.4,39.55) 186.4,41.61 186.01,41.99 186.01,47.53 187.6,49.11 PR35.2 191.22,52.02 191.73,52.02 192.49,52.79 192.49,54.03 192.36,54.16 192.36,54.91 192.49,55.04 192.49,56.86 R59.1
  IN1 w0.508: v5(185.63,21.29) 185.63,25.23 v5(186.01,25.61)
  IN3 w0.508: v6(186.4,39.55) 186.7,39.55 187.23,39.02 187.23,32.9 187.51,32.62 187.51,27.11 v5(186.01,25.61) ; v6(148.93,10.88) 151.72,13.67 161.12,13.67 161.63,14.18 164.55,14.18 164.93,14.56 172.91,14.56 173.62,15.27 182.18,15.27 185.63,18.72 v5(185.63,21.29)
  BOTTOM w0.508: JP2.2 145.99,9.19 146.34,8.83 C281.1 147.02,8.83 147.48,9.3 147.48,9.43 v7(148.17,10.11) v6(148.93,10.88)
+V3.3DX_TCH_SCR_R: length 1.4
  TOP w0.127: v7(186.9,47.4) 186.99,47.32 PR35.1
+V3.3S_1.8S_LPSS_SDIO: length 22.8
  TOP w0.508: C61.1 75.39,54.63 75.83,55.07 76.46,55.07 78.7,57.31 v7(78.7,57.87) 78.7,58.58 78.99,58.87 ; R64.1 R60.1 87.03,57.48 86.52,57.99 v6(86.52,58.6)
  IN1 w0.508: 79.69,58.96 79.89,58.96 80.43,58.42 82.46,58.42 82.64,58.6 v6(86.52,58.6)
  IN3 w0.508: v6(86.52,58.6) 86.85,58.28 87.47,58.28 87.78,57.97 92.39,57.97 92.67,58.25
  vias: v1(73.06,52.84) v1(73.47,52.94) v1(93.29,58.45) v1(93.6,58.45) v2(73.06,52.84) v2(73.47,52.94) v2(93.29,58.45) v2(93.6,58.45) v3(74.67,53.85) v3(74.93,53.86) v3(78.85,59.21) v3(79.23,59.21) v3(79.26,58.86) v4(74.67,53.85) v4(74.93,53.86) v4(78.85,59.21) v4(79.23,59.21) v4(79.26,58.86) v5(73.73,53.26) v8(93.29,58.45) v8(93.6,58.45)
+V5DX_AUDIO: length 66
  TOP w1.778: 88.68,28.99 76.59,28.99 76.26,28.66 67.22,28.66 65.91,29.96 52.91,29.96 52.29,30.59 44.54,30.59 42.03,33.1 28.53,33.1 25.77,35.87
  vias: v7(90.74,27.92) v10(23.58,37.8) v10(23.96,38.56) v10(24.34,37.8)
+VCCIN: length 61.9
  TOP w0.381: 42.45,59.14 42.45,61.57 42.07,61.96 40.73,61.96 v7(40.35,61.57) 39.46,61.57 38.95,61.07 R32.2
  BOTTOM w0.127: 52.32,58.65 52.32,58.44 U16.G43 ; U16.G29 61.08,58.55 61.44,58.55 U16.F28 ; U16.G29 60.62,58.44 60.62,58.67 ; U16.G29 61.03,58.03 ; U16.G29 60.5,57.97 60.5,57.97 ; U16.F24 63.99,58.21 ; U16.F24 63.58,58.59 ; U16.F24 63.98,58.6 63.98,59.16 ; U16.F24 64.36,58.59 ; U16.G53 46.09,57.92 ; U16.G53 45.64,58.16 45.64,58.09 45.48,57.92 ; U16.G53 45.99,58.51 ; U16.G53 45.59,58.42 45.59,58.68 ; 49.3,58.41 49.49,58.41 U16.G47 ; U16.F36 56.46,58.59 56.46,59.16 ; U16.F36 56.83,58.59 ; U16.F36 56.1,58.59 ; U16.F36 56.47,58.19 ; 48.52,58.53 U16.G49 ; U16.G49 48.55,57.97 ; U16.G49 48.18,58.19 48.18,57.84 ; U16.G49 48.08,58.44 48.08,58.71 ; U16.F44 51.45,59.15 ; U16.F44 51.82,58.59 ; U16.F44 51.09,58.59 ; U16.F44 51.45,58.22 ; U16.G37 55.94,58.42 55.94,58.66 ; U16.G37 55.78,58.25 55.49,57.96 ; U16.G37 56.02,58.02 ; U16.G37 55.6,58.44 55.6,58.65 ; U16.G33 58.12,58.43 58.12,58.65 ; U16.G33 58.58,57.97 ; U16.G33 58.54,58.52 ; U16.G33 58.25,58.26 57.95,57.97 ; U16.F32 58.61,58.59 ; U16.F32 59.34,58.59 ; U16.F32 58.98,58.23 ; U16.F32 58.98,59.16 ; 61.48,59 61.48,58.99 U16.F28 ; 46.88,58.51 U16.G51 ; U16.G51 47.3,58.43 47.3,58.63 ; U16.G51 46.86,57.99 ; U16.G51 47.4,57.99 ; 49.98,57.93 49.65,58.26 U16.G47 ; 55,57.95 54.68,58.26 U16.G39 ; U16.G23 64.84,58.42 64.84,58.68 ; U16.G23 64.48,58.46 64.48,58.66 ; U16.G23 64.97,57.98 64.97,57.61 U16.H23 ; U16.G23 64.39,57.97 ; U16.G41 53.24,58.26 52.94,57.96 ; U16.G41 53.13,58.4 53.13,58.73 ; U16.G41 53.56,57.97 ; U16.G41 53.54,58.53 ; 44.92,57.9 44.73,58.09 44.73,58.15 U16.G55 ; U16.F56 44.3,58.59 ; U16.F56 43.57,58.59 ; U16.F56 43.93,58.12 ; U16.F56 43.93,59.17 ; U16.G47 49.78,58.41 49.78,58.68 ; U16.G47 49.4,58.02 ; U16.G55 44.78,58.42 44.78,58.65 ; U16.G55 44.32,58.57 ; U16.G55 44.34,57.98 ; U16.F40 53.96,59.15 ; U16.F40 54.33,58.59 ; U16.F40 53.96,58.22 ; U16.F40 53.6,58.59 ; U16.F52 46.8,58.59 ; U16.F52 46.07,58.59 ; U16.F52 46.44,57.89 ; U16.F52 46.44,59.16 ; 51.07,57.95 U16.G45 ; U16.G45 51.05,58.55 ; U16.G45 50.61,58.41 50.61,58.65 ; U16.G45 50.52,58.02 ; 43.24,58.71 U16.G57 ; U16.G57 43.07,58.09 42.88,58.09 42.87,58.1 ; U16.G57 43.53,57.97 ; U16.G57 43.02,58.48 43.02,58.65 ; 60.02,57.94 59.69,58.26 U16.G31 ; 59.38,58.55 U16.G31 ; U16.G31 59.43,58.03 ; U16.G31 59.84,58.44 59.84,58.68 ; U16.G43 51.91,58.03 ; U16.G43 52.35,58.06 52.35,57.87 ; U16.G43 51.86,58.55 ; U16.H23 64.52,57.16 ; U16.H23 64.61,57.83 ; 54.81,58.65 54.81,58.43 U16.G39 ; U16.G39 54.4,58.01 ; U16.G39 54.37,58.54 ; 61.85,58.59 U16.F28 ; U16.F28 61.48,58.25 ; 42.17,57.92 41.99,58.11 U16.F59 ; U16.F59 42.37,58.24 ; U16.F59 41.99,58.64 ; 56.91,58.02 U16.G35 56.86,58.56 ; U16.F48 48.95,58.59 48.95,59.16 ; U16.F48 48.58,58.59 ; U16.F48 49.31,58.59 ; U16.F48 48.95,58.22
  BOTTOM w0.254: 43.1,48.89 42.96,48.75 U16.AD57 42.96,48.13 43.11,47.97 ; 43.27,52.65 U16.U57 42.96,52.06 43.14,51.87 ; 64.64,55.66 U16.K23 ; U16.K23 64.53,56.28 ; U16.K23 65,55.91 U16.L22 65,55.1 U16.M23 ; 43.12,55.37 42.96,55.2 U16.M57 42.96,54.66 43.15,54.47 ; 42.96,50.69 U16.W57 42.96,51.38 ; 64.62,57 U16.J23 64.67,56.5 ; 43.14,55.78 42.98,55.94 42.98,56.21 U16.K57 42.98,56.26 42.98,56.57 ; 43.13,54.05 43.13,54.05 42.96,53.88 U16.P57 42.96,53.34 43.13,53.17 ; U16.M23 64.52,54.72 ; U16.M23 64.64,55.37 ; 43.1,50.13 42.96,49.98 U16.AB57 42.96,49.41 43.06,49.31
  vias: v6(43.59,56.24) v6(43.59,54.94) v6(43.59,53.64) v6(43.59,52.34) v6(43.59,51.03) v6(43.59,49.73) v6(43.59,48.43) v6(43.63,47.13) v6(44.63,57.54) v6(45.76,57.54) v6(47.14,57.54) v6(48.27,57.54) v6(49.65,57.54) v6(50.77,57.54) v6(52.14,57.56) v6(53.33,57.52) v6(54.57,57.53) v6(55.86,57.55) v6(57.16,57.56) v6(58.4,57.51) v6(59.59,57.51) v6(60.79,57.56) v6(62.19,57.5) v6(63.32,57.5) v6(64.07,57.54) v6(64.07,56.73) v6(64.07,55.91) v6(64.07,55.1) v7(24.34,46.89) v10(28.51,49.56) v10(28.97,50.19) v10(29.32,49.53) v10(29.7,50.19) v10(30.08,49.53) v10(30.06,48.8) v10(30.06,48.06) v10(30.06,47.32) v10(30.06,46.59) v10(30.06,45.85) v10(30.44,50.19) v10(30.82,49.53) v10(30.79,48.8) v10(30.79,48.06) v10(30.79,47.32) v10(30.82,46.56) v10(31.18,50.19) v10(31.53,48.8) v10(31.53,48.06) v10(31.53,47.32) v10(31.56,49.53) v10(44.03,55.58) v10(44.03,54.31) v10(44.03,52.91) v10(44.03,51.64) v10(44.03,50.37) v10(44.03,49.1) v10(44.03,47.71) v10(45.17,57.1) v10(46.44,57.1) v10(47.71,57.1) v10(48.98,57.1) v10(50.19,57.11) v10(51.39,57.1) v10(52.68,57.08) v10(53.93,57.1) v10(55.2,57.1) v10(56.47,57.1) v10(57.74,57.1) v10(59.01,57.1) v10(60.21,57.11) v10(61.55,57.1)
+VCCIO_OUT: length 21
  IN3 w0.508: v2(42.22,62.54) 43.16,61.6 43.16,60.74 43.71,60.2 43.71,59.05 42.2,57.55 41.61,57.55 41.6,57.54 39.97,57.54 37.37,54.94 35.71,54.94 v6(34.6,53.83) 34.32,53.55 32.94,53.55 v6(32.49,54)
  BOTTOM w0.305: U16.A59 42.11,62.05 42.22,62.16 v2(42.22,62.54)
  BOTTOM w0.508: v6(32.49,54) 32.54,54 32.98,54.44 R283.1 ; R288.1 34.32,53.55 v6(34.6,53.83) 35,53.43 R290.1
+VCCIOA_OUT: length 2.3
  TOP w0.508: R40.2 67.45,59.28 v6(67.45,59.62) 68.03,59.62 v6(68.11,59.69)
  BOTTOM w0.305: v6(67.45,59.62) 66.92,59.1 U16.E20
AGND_LB: length 25.2
  TOP w0.203: PR16.2 186.66,60.27 186.68,60.24 PC3.2 v6(187.36,59.64) 187.36,59.24 186.95,58.83 184.77,58.83 184.41,58.48 184.41,57.66 184.39,57.64 184.39,57.08 184.13,56.82 183.19,56.82 183.01,57.01 PC5.2 182.54,57.38 182.37,57.55 PC4.2 ; PR9.2 187.53,65.43 187.59,65.38 PC1.2 PR6.2 v6(189.24,64.67) ; PU1.5 184.38,63.19 v6(184.39,63.17) ; PR12.2 v6(187.49,63.1) ; PR10.2 176.01,63.25 174.94,64.32 174.94,64.88 175.7,65.64 175.7,66.7 176.64,67.64 179.16,67.64 PR1.2 180.16,67.02 v6(180.43,67.29)
  vias: v7(185.89,63.71)
GND: length 239.7
  TOP w0.127: v10(12.15,54.28) 12.15,55.07 v7(12.18,55.1) ; v7(173.7,52.35) 173.66,52.32 172.93,52.32 v10(172.85,52.4) ; v7(156.17,64.88) v10(156.17,64.09) ; v3(190.31,46.41) 190.33,46.38 PU5.11 ; v6(20.94,7.29) 22.13,7.29 v7(22.21,7.22) ; v7(14.01,10.62) 14.01,10.63 v6(14.01,11.37) ; v10(176.84,60.8) 176.1,60.8 v7(175.96,60.66)
  TOP w0.152: v6(170.54,17.76) 170.54,17.76 PU16.11
  TOP w0.178: v6(191.31,26.12) PU14.15 PU14.11
  TOP w0.191: PU3.11 v3(123.12,50.86) ; PU15.11 v3(203.79,20.38) ; PU13.11 94.85,27.74 v3(94.68,27.92)
  TOP w0.203: U13.6 183.86,27.67 v6(183.75,27.56) ; PQ7.4 149.65,45.59 v3(149.37,45.86) ; PU10.14 119.04,36.56 ; PU10.3 120.08,36.96 ; PC73.1 151.17,34.62 v6(151.22,34.57) ; PU10.1 120.24,36.16 ; v6(181.67,32.72) 181.67,32.85 182.04,33.22 182.07,33.22 182.14,33.28 183.02,33.28 183.35,33.61 U11.6
  TOP w0.254: PQ6.4 103.82,47.19 103.72,47.09 v3(103.1,47.09) ; JKB1.30 161.5,15.65 v6(160.56,14.71) ; Q4.4 129.51,63.45 v3(129.25,63.71) ; v3(132.42,56.09) 132.27,56.09 132.05,56.3 PQ1.1 ; U10.44 109.66,35.86 ; v3(130.41,54.13) 130.59,54.13 130.75,54.29 PQ1.4 ; PQ6.1 v3(107.96,45.89) ; v3(88.17,38.04) U9.3 ; U7.14 v3(200.06,47.53) ; ESD1.2 v3(206.08,45.04)
  TOP w0.305: U6.25 v3(150.47,56.81)
  TOP w0.381: PC130.2 7.08,10.39 v10(7.55,10.39) ; PQ32.1 10.37,17.51 v6(11.08,18.22) ; EC13.2 121.78,23.11 121.24,23.65 ; C131.1 v6(199.1,39.73) ; 121.24,23.65 121.24,23.65 120.61,23.01 EC14.2 ; 121.24,23.65 v6(121.24,23.68) ; JKB1.32 162.98,11.18 v6(163.2,10.95) ; PU18.40 25.56,57.63 SJ1.1 ; v6(207.25,21.59) 206.57,21.59 PC112.2 206.11,19.99 PC114.2 ; PC105.2 193.12,22.02 PC106.2 194.16,22.46 v6(194.29,22.33) ; C191.2 15.61,11.84 14.48,11.84 v6(14.01,11.37) ; v6(193.26,25.67) 193.64,26.05 PC100.2 ; v3(124.67,43.14) 124.67,43.28 125.11,43.72 126.11,43.72 PC40.2 v3(126.7,42.12) ; PC125.2 172.48,15.17 172.47,15.17 172.2,15.45 v6(172.2,15.47) ; C63.2 198.9,53.41 199.02,53.29 v6(199.35,53.29) ; C130.1 v6(198.08,39.73) ; v6(193.58,44.1) 193.4,44.29 PC37.2 ; PC116.2 168.92,19.44 PC117.2 PC118.2 v6(171.03,20.27) ; PC71.2 v6(190.31,35.67) ; v6(195.74,38.56) PC62.2 ; v6(191.75,21.8) 191.26,21.8 PC107.2 ; PC77.2 163.89,33.1 v10(163.95,33.04) ; v6(190.15,21.7) 190.01,21.84 PC108.2 ; PU11.2 v6(198.21,35.41) ; 159.73,21.04 159.73,20.68 v6(160.49,19.92) ; PC79.2 v6(195.54,33.15) ; PC99.2 189,26.05 189.6,25.46 v6(189.6,25.25) ; PR118.2 v6(110.63,26.67) ; v6(14.01,14.57) 13.33,13.89 R242.2 ; C163.2 197.76,30.93 v6(197.75,30.94) ; v6(194.38,38.55) PC61.2 ; C14.2 v6(160.1,61.81) ; PR93.2 v6(190.28,34.5) ; PQ12.1 11.16,19.16 v6(11.47,18.85) ; PC124.2 168.09,14.87 167.47,14.25 v6(167.47,13.19)
  TOP w0.508: Q20.1 v6(218.3,12.68) ; PR231.2 122.9,22.94 123.4,23.45 v6(123.4,24.11) ; v6(153.97,26.89) 153.61,26.89 153.15,26.42 PQ31.1 ; PR132.2 126.72,15.81 126.07,16.46 v10(125.69,16.46) ; v6(106,15.32) 106,15.8 v7(106.39,16.18) 106.89,16.69 ESD2.2 ; v3(85.99,45.28) v3(84.97,45.28) ; RTCR2.2 v6(205.57,37.55) ; v10(15.83,61.73) 14.72,61.73 13.53,60.54 EC77.2 ; RTCBT1.1 215.2,17.57 v6(214.59,18.18) ; v6(170.72,44.52) 170.83,44.41 R461.2 ; PR147.2 135.71,9.09 v7(136.33,9.71) 137.12,10.49 v6(137.12,10.7) ; v6(136.36,11.13) 136.83,11.6 JKB1.31 ; C69.2 130.63,52.66 129.66,52.66 v6(129.61,52.61) ; PC13.2 v10(16.22,53.29)
  IN3 w0.089: v5(192.44,46.13) 192.52,46.05 v2(192.52,45.78)
  IN3 w0.254: v2(189.32,44.58) 189.24,44.58 v5(189.04,44.78) ; v2(190.69,44.89) 190.84,44.73 v5(190.84,44.58) ; v2(147.36,17.71) 147.58,17.94 v5(147.58,18.04) ; v2(146.75,16.56) 146.75,16.38 v5(146.9,16.24) ; v5(191.53,46.16) v2(191.27,45.9)
  IN3 w0.508: H1.1 211.1,68.17 211.08,68.15 ; H10.1 213.7,14.2
  IN4 w0.127: v5(44.03,44.25) 43.77,44 v2(43.77,43.82) ; v2(50.44,46.1) 50.56,46.1 v5(50.76,45.9) ; v5(44.97,44.56) 44.97,44.94 v2(44.79,45.11) ; v5(45.55,45.93) 45.38,46.1 v2(45.24,46.1) ; v2(47.61,45.11) 47.61,44.71 v5(47.63,44.68)
  IN4 w0.254: v2(49.34,60.74) 49.36,60.71 v5(49.36,60.13) ; v5(46.54,60.38) 46.44,60.48 v2(46.44,60.74) ; v2(48.68,61.65) 48.57,61.65 v5(48.35,61.42) ; v2(41.01,48.91) 40.74,48.65 v5(40.29,48.65) 40.19,48.54 v2(39.39,48.54) ; v2(47.28,60) 47.25,60.02 v5(46.92,60.02) ; v2(43.24,60.41) 42.98,60.41 v5(42.81,60.25) ; v5(41.79,52.94) 41.86,52.94 v2(42.33,53.41) ; v2(40.69,52.25) 40.69,52.24 v5(40.37,51.92) ; v5(43.01,59.72) 43.19,59.9 v2(43.29,59.9) ; v5(41.11,56.9) 41.31,57.1 v2(41.63,57.1) ; v2(45.75,59.88) 45.8,59.93 46.07,59.93 v5(46.16,60.02) ; v2(39.39,50.79) 39.73,50.79 v5(39.91,50.97) ; v2(42.43,55.17) 42.3,55.05 42.17,55.05 v5(42.12,55) ; v2(42.3,52.66) 42.3,52.65 42.08,52.43 v5(41.79,52.43)
  BOTTOM w0.127: v10(28.79,66.63) 29.63,66.63 v7(29.65,66.6) ; U16.D39 v2(54.65,59.74) ; C223.2 96.22,27.42 v7(96.2,27.44) ; v10(180.83,62.97) 180.83,63.96 v7(180.81,63.99) ; v2(204.66,46.18) v2(205.46,46.18) ; v7(43.01,35.16) 43.24,35.39 C265.2 ; U16.C39 v2(54.65,60.54) ; v7(213.85,18.11) 213.92,18.18 v6(214.59,18.18)
  BOTTOM w0.178: 15.49,53 PQ19.3 ; PU18.29 25.42,56.78
  BOTTOM w0.203: 25.42,56.78 PU18.41 ; CN3.42 v2(16.9,37.93) ; CN3.38 14.9,37.55 v2(15.25,37.9) ; PU17.24 106.32,59.66 106.46,59.52 107.11,59.52 v6(107.4,59.22) 107.3,59.12 106.27,59.12 105.92,59.47 PU17.25 ; PU17.20 108.07,62.09 v6(108.28,62.3) 108.09,62.49 PU17.19 ; CN3.37 v2(14.4,37.9)
  BOTTOM w0.216: U18.T9 v6(14.01,11.37) ; U18.P9 v6(14.01,12.97) ; U18.M9 v6(14.01,14.57)
  BOTTOM w0.254: v2(32.21,51.52) 31.9,51.21 R300.2 ; CN3.45 18.4,38.02 18.93,38.56 v6(18.93,38.65) ; U16.B48 49.28,60.74 49.29,60.74 v2(49.34,60.74) ; v2(9.76,38.21) 9.9,38.07 CN3.28 ; U16.Y59 v2(42.3,51.06) ; v2(174.05,27.93) 174.02,27.9 CN4.39 ; v2(48.17,59.85) 48.17,59.85 U16.D49 ; U16.L58 42.43,55.38 v2(42.43,55.17) ; U16.D47 49.69,59.82 v2(49.69,59.85) ; v2(42.3,52.66) 42.31,52.66 U16.T58 ; U16.AC61 40.69,49.24 v2(41.01,48.91) ; v2(47.28,60) 47.28,59.91 U16.D51 ; U17.3 28.39,40.71 28.89,40.2 R346.2 ; U16.P59 v2(42.33,53.41) ; CN4.45 174.18,26.4 v2(174.2,26.38) ; U16.J59 v2(41.63,57.1) ; v2(11.43,38.3) 11.4,38.27 CN3.31 ; v2(48.68,61.65) 48.68,61.65 U16.A48 ; v2(43.29,59.9) 43.29,59.81 U16.D57 ; CN4.33 174.32,29.4 v2(174.33,29.39) ; CN4.7 171.85,35.9 v6(170.85,34.9) ; U16.D53 v2(45.75,59.88)
  BOTTOM w0.305: v2(174.29,23.4) CN4.57 ; CN3.34 12.9,37.71 13.05,37.86 13.05,38.55 v6(12.95,38.65) ; v6(16.49,38.59) 16.49,38.56 16.4,38.47 CN3.41 ; v6(171.03,20.27) 171.27,20.27 171.63,19.92 171.63,19.18 171.91,18.9 CN4.75 ; CN4.63 v2(174.3,21.9) ; CN4.18 181.27,33.15 181.67,32.75 v6(181.67,32.72) ; v2(174.32,24.9) CN4.51 ; v2(174.37,20.4) CN4.69
  BOTTOM w0.381: R394.2 218.78,15.07 v6(218.02,15.83) ; C275.2 160.08,19.51 v6(160.49,19.92) ; R384.2 v6(219.59,27.13) ; PC152.2 110.22,60.13 110.45,59.9 v6(110.45,59.52) ; PC194.2 PC195.2 120.28,24.01 v6(120.48,23.8) ; v6(26.88,43.26) 27.37,43.75 PC175.2 ; PC163.2 29.55,53.27 v6(29.92,53.63) ; v6(153.88,20.22) 153.55,19.89 JP1.4 ; v6(147.38,10.88) 147.33,10.88 146.59,10.14 C281.2 ; PC209.2 184.98,13.55 v6(185.12,13.42) PR214.2 ; PC156.2 107.41,59.21 v6(107.4,59.22) ; v6(213.63,30.81) EC60.2 ; C276.2 v6(218.89,19.12) ; R392.2 170.77,20.01 v6(171.03,20.27) ; R387.2 v6(218.89,21.93)
  BOTTOM w0.406: CN1.14 v2(208.11,61) ; CN1.8 v2(208.11,62.8)
  BOTTOM w0.457: v6(125.74,30.08) 126.53,30.87 SJ5.2
  BOTTOM w0.508: v6(39.28,6.84) 38.87,6.84 C286.2 ; CN6.6 v6(191.85,18.45) ; JP1.10 146.39,15.55 v6(145.86,15.02) ; JP2.10 142.55,14.4 v6(143.1,13.85) 143.76,13.19 JP2.7 ; EC61.1 216.57,32.31 v6(216.7,32.44) ; CN4.77 170.57,17.8 v6(170.54,17.76) ; CN6.8 189.7,15.07 v6(190.46,15.83) ; v6(88.07,6.81) 87.49,6.81 C311.2 ; EC72.2 v6(23.21,63.06) ; EC58.2 EC57.2 EC56.2 18.84,39.59 18.44,39.19 18.44,39.18 v6(18.45,39.18) ; v6(170.57,15.47) 170.22,15.82 J2.5 ; v6(42.1,6.81) 42.33,6.81 C283.2 ; v6(20.94,7.29) 21.14,7.09 C291.2 ; v6(98.66,6.84) 99.02,6.84 C284.2 ; v6(196.68,14.81) 198.04,14.81 CN6.7 ; v6(29.75,57.25) 29.25,57.74 PC160.2 ; R346.2 28.86,40.15 v6(28.07,39.36) ; CON1.54 164.91,34 v10(163.95,33.04) ; EC65.2 v6(12.79,31.32) ; J2.6 161.67,15.82 v6(160.56,14.71) 159.72,15.55 JP1.9 ; v6(27.62,6.84) 27.14,6.84 C293.2 ; v6(54.57,6.89) 54.01,6.89 C297.2 ; PC144.2 v6(111.44,62.67) ; CN5.4 v6(212.28,27.84) ; v6(21.02,68.13) 21.42,67.72 EC76.2 ; CN5.3 v6(217.93,23.96)
  vias: v1(9.97,38.56) v1(11.14,38.59) v1(11.72,38.61) v1(12.35,38.59) v1(28.15,17.99) v1(28.51,17.38) v1(39.43,18.14) v1(39.46,16.57) v1(39.71,47.11) v1(40.36,47.11) v1(41.01,47.11) v1(41.66,47.11) v1(41.66,45.76) v1(42.64,51.68) v1(42.64,50.38) v1(42.64,46.1) v1(43.29,46.43) v1(44.59,46.43) v1(45.89,46.43) v1(47.19,46.43) v1(47.76,42.09) v1(48.49,46.43) v1(48.6,40.39) v1(48.68,45.06) v1(49.64,62.13) v1(49.79,46.43) v1(49.92,43.13) v1(50.15,41.53) v1(50.58,43.9) v1(50.63,7.45) v1(50.76,62.13) v1(51.09,46.43) v1(51.32,40.16) v1(52.28,7.45) v1(52.39,46.43) v1(52.64,42.24) v1(52.71,42.63) v1(52.92,40.11) v1(53.04,46.1) v1(53.55,43.13) v1(53.63,39.45) v1(53.69,46.43) v1(53.93,41.48) v1(54.29,40.06) v1(54.42,41.48) v1(54.47,43.16) v1(54.59,40.06) v1(54.9,42.65) v1(54.99,46.43) v1(55.23,38.84) v1(55.36,42.83) v1(56.02,41.48) v1(56.12,43.87) v1(56.29,46.43) v1(56.43,44.8) v1(56.43,43.5) v1(56.6,7.83) v1(56.94,46.1) v1(57.08,41.46) v1(57.59,46.43) v1(57.62,42.52) v1(57.62,41.08) v1(57.57,40.49) v1(58.13,7.55) v1(58.56,43.18) v1(58.56,40.06) v1(58.71,45.67) v1(58.89,46.43) v1(59.4,65.49) v1(59.4,64.85) v1(59.45,41.86) v1(59.78,45.67) v1(59.9,65.49) v1(59.9,64.85) v1(60.19,46.43) v1(60.41,65.49) v1(60.41,64.85) v1(60.84,46.1) v1(61.49,46.43) v1(61.68,67.26) v1(61.68,66.5) v1(62.14,46.1) v1(62.19,67.26) v1(62.19,66.5) v1(62.7,67.26) v1(62.7,66.5) v1(63,45.5) v1(62.98,44.15) v1(64.09,46.43) v1(64.89,44.2) v1(65.8,45.47) v1(65.8,44.84) v1(65.8,44.15) v1(65.82,43.49) v1(65.85,42.91) v1(67.7,45.5) v1(67.68,44.15) v1(69.15,44.25) v1(72.07,18.14) v1(72.37,17.38) v1(83.07,18.11) v1(83.27,16.57) v1(139.96,14.36) v1(141.34,14.28) v1(142.62,10.32) v1(151.24,21.39) v1(163.54,37.22) v1(164.68,36.81) v1(169.43,23.64) v1(170.5,23.62) v1(171.56,27.88) v1(175.45,27.77) v1(175.42,26.47) v1(178.83,48.01) v1(180.35,47.96) v1(184.87,46.64) v1(185.86,46) v1(191.18,38.5) v1(191.2,37.49) v1(196.61,45.7) v1(197.88,46.11) v1(199.78,47.83) v1(199.78,46.51) v1(206.59,47.55) v1(206.58,46.18) v1(206.72,44.86) v1(206.79,46.41) v1(206.77,45.9) v1(207.68,60.96) v1(208.11,59.67) v2(4.02,6.43) v2(4.15,17.1) v2(4.15,16.34) v2(4.79,6.43) v2(4.91,17.1) v2(4.91,16.34) v2(5.67,17.1) v2(5.67,16.34) v2(5.67,6.43) v2(6.31,17.1) v2(6.31,16.34) v2(6.69,6.43) v2(6.79,22.6) v2(6.94,20.53) v2(6.94,19.51) v2(6.94,18.5) v2(6.94,17.1) v2(6.94,16.34) v2(8.09,35.64) v2(8.15,35) v2(8.09,34.37) v2(8.6,31.32) v2(9.97,38.56) v2(10.22,22.95) v2(11.14,38.59) v2(11.11,16.63) v2(11.72,38.61) v2(11.9,33.2) v2(12.35,38.59) v2(12.74,9.25) v2(14.41,22.97) v2(14.41,22.17) v2(14.41,18.97) v2(14.41,18.17) v2(14.5,30.54) v2(15.21,20.57) v2(15.21,19.77) v2(15.21,18.17) v2(15.21,16.57) v2(15.73,7.47) v2(16.01,19.77) v2(17.4,33.2) v2(17.74,7.42) v2(19.21,22.17) v2(19.21,20.57) v2(20.01,19.77) v2(20.01,16.57) v2(20.23,7.19) v2(20.41,30.42) v2(20.81,22.17) v2(20.81,20.57) v2(20.81,19.77) v2(20.81,18.17) v2(20.81,14.17) v2(20.81,12.57) v2(20.81,10.97) v2(21.42,30.42) v2(22.94,41.86) v2(23.45,7.45) v2(24.65,35) v2(24.6,7.45) v2(25.59,22.97) v2(25.59,22.17) v2(25.59,18.97) v2(25.59,18.17) v2(25.59,14.17) v2(25.59,12.57) v2(25.59,10.98) v2(26.35,66.96) v2(26.35,65.94) v2(26.35,64.93) v2(26.39,20.57) v2(26.39,19.77) v2(26.39,18.17) v2(26.39,16.57) v2(26.76,26.74) v2(27.11,66.96) v2(27.11,65.94) v2(27.11,64.93) v2(27.19,19.77) v2(27.87,66.96) v2(27.87,65.94) v2(27.87,64.93) v2(28.15,17.99) v2(28.51,17.38) v2(28.91,26.62) v2(29.3,7.45) v2(30.39,22.17) v2(30.39,20.57) v2(30.69,7.45) v2(31.19,19.77) v2(31.19,16.57) v2(31.84,7.45) v2(31.96,27.52) v2(31.99,22.17) v2(31.99,20.57) v2(31.99,19.77) v2(31.99,18.17) v2(31.99,14.17) v2(31.99,12.57) v2(31.99,10.97) v2(32.98,27.51) v2(32.98,7.45) v2(34,27.51) v2(34.12,7.35) v2(34.24,51.52) v2(35.01,27.51) v2(35.32,7.4) v2(36.03,27.51) v2(36.79,28.91) v2(36.79,28.15) v2(36.79,27.26) v2(36.79,26.5) v2(36.76,22.97) v2(36.76,22.17) v2(36.76,18.97) v2(36.76,18.17) v2(36.76,14.17) v2(36.76,12.57) v2(36.76,10.97) v2(37.17,7.57) v2(37.56,20.57) v2(37.56,19.77) v2(37.56,18.17) v2(37.56,16.57) v2(37.7,28.66) v2(37.75,27.94) v2(37.81,27.26) v2(37.75,26.67) v2(38.36,19.77) v2(38.72,28.66) v2(38.77,27.94) v2(38.82,27.26) v2(38.77,26.67) v2(39.35,66.65) v2(39.39,59.74) v2(39.39,56.78) v2(39.39,53.78) v2(39.39,41.87) v2(39.43,18.14) v2(39.46,16.57) v2(39.71,47.11) v2(39.71,45.76) v2(39.71,43.33) v2(40.04,59.68) v2(40.04,53.78) v2(40.2,42.02) v2(40.36,47.11) v2(40.69,58.24) v2(40.69,55.24) v2(40.9,7.55) v2(41.01,47.11) v2(41.01,44.54) v2(41.01,42.08) v2(41.35,61.05) v2(41.45,39.74) v2(41.62,66.53) v2(41.56,22.17) v2(41.56,20.57) v2(41.66,47.11) v2(41.66,45.76) v2(41.66,44.54) v2(41.66,43.33) v2(41.93,39.09) v2(42.01,41.36) v2(42.01,40.71) v2(42.01,40.06) v2(42.11,59.76) v2(42.36,19.77) v2(42.36,16.57) v2(42.64,58.59) v2(42.64,51.68) v2(42.64,50.38) v2(42.64,47.78) v2(42.64,46.1) v2(42.96,57.61) v2(43.16,22.17) v2(43.16,20.57) v2(43.16,19.77) v2(43.16,18.17) v2(43.16,14.17) v2(43.16,12.57) v2(43.16,10.97) v2(43.29,46.43) v2(43.25,41.36) v2(43.25,39.41) v2(43.51,44.8) v2(43.51,42.85) v2(43.8,35.62) v2(43.8,35.16) v2(43.93,61.39) v2(43.93,60.74) v2(43.94,46.1) v2(44.03,7.45) v2(44.26,35.62) v2(44.26,35.16) v2(44.47,41.36) v2(44.47,40.71) v2(44.62,59.76) v2(44.59,46.43) v2(45.18,59.44) v2(45.18,58.59) v2(45.17,7.45) v2(45.4,44.8) v2(45.4,42.85) v2(45.68,41.36) v2(45.68,39.41) v2(45.89,46.43) v2(46.31,7.45) v2(46.44,61.39) v2(46.43,45.45) v2(46.43,44.8) v2(46.43,44.15) v2(46.43,43.5) v2(46.43,42.85) v2(46.43,42.2) v2(46.54,46.1) v2(47.03,41.36) v2(47.03,40.71) v2(47.03,40.06) v2(47.03,39.41) v2(47.19,46.43) v2(47.25,44.8) v2(47.25,43.5) v2(47.69,59.44) v2(47.69,58.59) v2(47.72,39.74) v2(47.84,46.1) v2(47.76,42.09) v2(47.94,22.97) v2(47.94,22.17) v2(47.94,18.97) v2(47.94,18.17) v2(47.94,14.17) v2(47.94,12.57) v2(47.94,10.98) v2(48.1,41.47) v2(48.09,7.7) v2(48.26,43.5) v2(48.26,42.2) v2(48.49,46.43) v2(48.6,40.39) v2(48.68,45.06) v2(48.74,20.57) v2(48.74,19.77) v2(48.74,18.17) v2(48.74,16.57) v2(49.14,46.1) v2(49.16,43.5) v2(49.16,42.85) v2(49.29,39.74) v2(49.54,19.77) v2(49.64,62.13) v2(49.7,41.49) v2(49.79,46.43) v2(49.92,43.13) v2(50.15,41.53) v2(50.12,40.39) v2(50.2,59.44) v2(50.2,58.59) v2(50.21,44.8) v2(50.21,43.5) v2(50.58,43.9) v2(50.63,7.45) v2(50.76,62.13) v2(50.76,59.76) v2(50.87,39.74) v2(51.09,46.43) v2(51.14,44.8) v2(51.14,43.5) v2(51.28,41.49) v2(51.32,40.16) v2(51.45,61.39) v2(51.45,60.74) v2(51.74,46.1) v2(51.7,40.39) v2(51.78,26.74) v2(52.03,66.12) v2(52.14,59.76) v2(52.12,43.5) v2(52.12,42.2) v2(52.28,7.45) v2(52.39,46.43) v2(52.44,39.74) v2(52.64,42.24) v2(52.71,59.44) v2(52.71,58.59) v2(52.71,42.63) v2(52.74,22.17) v2(52.74,20.57) v2(52.85,41.49) v2(52.92,40.11) v2(52.94,33.46) v2(52.94,33) v2(53.05,66.88) v2(53.04,46.1) v2(53.07,43.5) v2(53.27,59.76) v2(53.27,40.39) v2(53.4,33.46) v2(53.4,33) v2(53.54,19.77) v2(53.54,16.57) v2(53.55,43.13) v2(53.63,39.45) v2(53.68,66.88) v2(53.69,46.43) v2(53.88,44.8) v2(53.88,43.5) v2(53.93,41.48) v2(53.93,26.62) v2(53.96,61.39) v2(53.96,60.74) v2(54.02,39.74) v2(54.21,33.46) v2(54.21,33) v2(54.32,66.88) v2(54.34,46.1) v2(54.29,40.06) v2(54.34,22.17) v2(54.34,20.57) v2(54.34,19.77) v2(54.34,18.17) v2(54.34,14.17) v2(54.34,12.57) v2(54.34,10.97) v2(54.42,41.48) v2(54.47,45.12) v2(54.47,43.82) v2(54.47,43.16) v2(54.47,42.52) v2(54.59,40.06) v2(54.67,33.46) v2(54.67,33) v2(54.84,40.39) v2(54.95,66.88) v2(54.9,42.65) v2(54.99,46.43) v2(55.21,60.09) v2(55.21,59.44) v2(55.21,58.59) v2(55.23,38.84) v2(55.36,42.83) v2(55.59,39.74) v2(55.78,59.76) v2(56.02,41.48) v2(56.12,43.87) v2(56.29,46.43) v2(56.43,44.8) v2(56.43,43.5) v2(56.42,40.39) v2(56.47,61.39) v2(56.47,60.74) v2(56.6,7.83) v2(56.94,46.1) v2(57.08,41.46) v2(57.16,59.76) v2(57.16,39.74) v2(57.29,43.5) v2(57.59,46.43) v2(57.62,42.52) v2(57.58,41.49) v2(57.62,41.08) v2(57.57,40.49) v2(57.72,59.44) v2(57.72,58.59) v2(57.99,40.39) v2(58.13,7.55) v2(58.23,22.97) v2(58.23,22.17) v2(58.23,18.97) v2(58.23,18.17) v2(58.23,14.17) v2(58.23,12.57) v2(58.23,10.97) v2(58.29,59.76) v2(58.29,44.8) v2(58.29,42.2) v2(58.56,43.18) v2(58.64,41.38) v2(58.61,40.71) v2(58.56,40.06) v2(58.56,39.41) v2(58.71,45.67) v2(58.89,46.43) v2(58.98,61.39) v2(58.98,60.74) v2(59.03,20.57) v2(59.03,19.77) v2(59.03,18.17) v2(59.03,16.57) v2(59.14,26.85) v2(59.14,26.4) v2(59.19,43.5) v2(59.4,65.49) v2(59.4,64.85) v2(59.45,41.86) v2(59.65,26.85) v2(59.65,26.4) v2(59.67,59.76) v2(59.78,45.67) v2(59.75,45.12) v2(59.75,44.47) v2(59.75,43.82) v2(59.75,43.17) v2(59.75,42.52) v2(59.83,19.77) v2(59.9,65.49) v2(59.9,64.85) v2(59.91,41.36) v2(59.91,39.41) v2(60.23,59.44) v2(60.23,58.59) v2(60.19,46.43) v2(60.41,65.49) v2(60.41,64.85) v2(60.65,44.8) v2(60.65,42.85) v2(60.79,59.76) v2(60.84,46.1) v2(61.13,41.36) v2(61.13,40.71) v2(61.17,7.32) v2(61.48,61.39) v2(61.48,60.74) v2(61.49,46.43) v2(61.68,67.26) v2(61.68,66.5) v2(62.14,46.1) v2(62.19,67.26) v2(62.19,66.5) v2(62.17,60.41) v2(62.17,59.76) v2(62.35,41.36) v2(62.35,39.41) v2(62.56,44.8) v2(62.56,42.85) v2(62.7,67.26) v2(62.7,66.5) v2(62.74,60.74) v2(62.74,59.44) v2(62.74,58.59) v2(63,45.5) v2(62.98,44.15) v2(62.96,26.61) v2(63.03,22.17) v2(63.03,20.57) v2(63.3,60.41) v2(63.3,59.76) v2(63.44,46.1) v2(63.36,7.45) v2(63.7,66.25) v2(63.71,64.98) v2(63.7,41.36) v2(63.7,40.71) v2(63.7,40.06) v2(63.7,39.41) v2(63.83,19.77) v2(63.83,16.57) v2(63.99,61.39) v2(63.99,60.74) v2(64.09,46.43) v2(64.18,26.84) v2(64.18,26.38) v2(64.49,45.45) v2(64.49,44.8) v2(64.49,44.15) v2(64.49,43.5) v2(64.49,42.85) v2(64.49,42.2) v2(64.64,59.93) v2(64.63,22.17) v2(64.63,20.57) v2(64.63,19.77) v2(64.63,18.17) v2(64.63,14.17) v2(64.63,12.57) v2(64.63,10.97) v2(64.69,26.84) v2(64.69,26.38) v2(64.81,34.92) v2(64.9,51.85) v2(64.9,46.97) v2(64.9,46.16) v2(64.89,44.2) v2(65.05,41.36) v2(65.05,39.41) v2(65.31,44.8) v2(65.31,42.85) v2(65.41,57.95) v2(65.41,56.32) v2(65.41,54.7) v2(65.41,53.88) v2(65.41,53.07) v2(65.41,52.26) v2(65.41,51.44) v2(65.41,49.82) v2(65.41,46.57) v2(65.78,59.29) v2(65.8,45.47) v2(65.8,44.84) v2(65.8,44.15) v2(65.82,43.49) v2(65.85,42.91) v2(65.82,34.92) v2(66.06,46.59) v2(66.13,7.47) v2(66.16,61.07) v2(66.33,54.29) v2(66.33,48.6) v2(66.26,41.36) v2(66.26,40.71) v2(66.5,60.52) v2(66.67,46.24) v2(66.84,58.45) v2(66.83,55.51) v2(66.83,52.26) v2(66.83,51.44) v2(66.83,49.82) v2(67.21,44.8) v2(67.21,42.85) v2(67.41,61.71) v2(67.51,60.52) v2(67.49,46.24) v2(67.48,41.36) v2(67.48,39.41) v2(67.7,45.5) v2(67.68,44.15) v2(67.79,57.79) v2(67.79,55.57) v2(67.91,59.93) v2(67.89,47.43) v2(68.03,7.45) v2(68.16,26.62) v2(68.3,46.24) v2(68.75,59.1) v2(68.75,57.14) v2(68.75,55.57) v2(68.7,47.43) v2(68.79,45.13) v2(68.79,44.48) v2(68.79,43.83) v2(68.79,43.18) v2(68.79,42.53) v2(68.79,41.36) v2(68.79,40.71) v2(68.79,40.06) v2(68.83,39.41) v2(69.11,46.24) v2(69.15,44.25) v2(69.4,22.97) v2(69.4,22.17) v2(69.4,18.97) v2(69.4,18.17) v2(69.4,14.17) v2(69.4,12.57) v2(69.4,10.98) v2(69.43,7.45) v2(69.52,47.43) v2(69.7,55.57) v2(69.92,45.59) v2(69.87,42.01) v2(69.98,61.71) v2(70.09,60.52) v2(70.18,40.39) v2(70.2,20.57) v2(70.2,19.77) v2(70.2,18.17) v2(70.2,16.57) v2(70.33,47.43) v2(70.34,32.97) v2(70.44,44.94) v2(70.44,41.69) v2(70.49,59.93) v2(70.65,57.14) v2(70.65,55.57) v2(70.74,45.59) v2(71,19.77) v2(70.95,7.35) v2(70.95,6.79) v2(71.13,56.01) v2(71.14,47.43) v2(71.28,59.93) v2(71.41,7.35) v2(71.41,6.79) v2(71.55,46.92) v2(71.65,61.71) v2(71.6,59.1) v2(71.64,39.09) v2(71.66,60.52) v2(71.79,42.01) v2(71.96,47.43) v2(72.07,18.14) v2(72.36,44.94) v2(72.36,42.99) v2(72.37,17.38) v2(72.54,54.42) v2(72.54,53.47) v2(72.54,51.57) v2(72.54,50.61) v2(72.54,49.66) v2(72.54,47.76) v2(72.56,56.49) v2(72.98,52.04) v2(73.03,7.35) v2(73.18,40.39) v2(73.43,53.47) v2(73.51,57.79) v2(73.95,67.47) v2(73.95,67.06) v2(73.86,59.93) v2(74.08,55.38) v2(74.08,51.57) v2(74.08,49.66) v2(74.2,22.17) v2(74.2,20.57) v2(74.28,43.64) v2(74.25,7.32) v2(74.38,67.47) v2(74.38,67.06) v2(74.38,33.6) v2(74.46,57.79) v2(74.64,39.09) v2(74.64,26.24) v2(75,19.77) v2(75,16.57) v2(75.11,42.34) v2(75.34,59.87) v2(75.41,57.79) v2(75.38,47.76) v2(75.65,65.99) v2(75.8,22.17) v2(75.8,20.57) v2(75.8,19.77) v2(75.8,18.17) v2(75.8,14.17) v2(75.8,12.57) v2(75.8,10.97) v2(76.04,39.75) v2(76.09,61.06) v2(76.09,39.09) v2(76.71,57.53) v2(76.71,54.53) v2(76.71,51.53) v2(76.71,48.54) v2(76.71,45.54) v2(76.71,42.54) v2(76.82,67.37) v2(76.82,66.68) v2(76.79,26.36) v2(77.35,67.02) v2(77.36,59.64) v2(77.43,33.6) v2(77.43,7.45) v2(77.89,67.34) v2(77.89,66.68) v2(78.01,55.99) v2(78.01,52.99) v2(78.01,50) v2(78.01,47) v2(78.01,44) v2(78.01,41.06) v2(78.45,26.5) v2(78.57,7.45) v2(80.35,7.42) v2(80.58,22.97) v2(80.58,22.17) v2(80.58,18.97) v2(80.58,18.17) v2(80.58,14.17) v2(80.58,12.57) v2(80.58,10.97) v2(81.38,26.51) v2(81.38,20.57) v2(81.38,19.77) v2(81.38,18.17) v2(81.38,16.57) v2(81.65,7.42) v2(81.65,6.96) v2(82.14,36.78) v2(82.1,7.42) v2(82.1,6.96) v2(82.18,19.77) v2(83.07,18.11) v2(83.27,35.78) v2(83.27,32.96) v2(83.27,16.57) v2(83.53,58.25) v2(83.53,26.5) v2(83.66,54.11) v2(83.66,50.63) v2(83.79,49.03) v2(83.78,7.45) v2(85.38,22.17) v2(85.38,20.57) v2(85.69,51.64) v2(85.68,26.5) v2(85.68,7.45) v2(85.83,45.49) v2(86.18,19.77) v2(86.18,16.57) v2(86.7,36.66) v2(86.71,26.89) v2(86.71,26.38) v2(86.98,22.17) v2(86.98,20.57) v2(86.98,19.77) v2(86.98,18.17) v2(86.98,14.17) v2(86.98,12.57) v2(86.98,10.97) v2(87.22,26.89) v2(87.22,26.38) v2(87.97,36.66) v2(88.14,63.45) v2(88.12,62.61) v2(88.61,7.45) v2(89.24,36.66) v2(89.75,26.5) v2(90.01,38.31) v2(90.38,58.12) v2(90.39,57.1) v2(91.53,7.45) v2(91.76,22.97) v2(91.76,22.17) v2(91.76,18.97) v2(91.76,18.17) v2(91.76,14.17) v2(91.76,12.57) v2(91.75,10.98) v2(92.04,41.36) v2(92.42,57.1) v2(92.56,20.57) v2(92.56,19.77) v2(92.56,18.17) v2(92.56,16.57) v2(92.69,33.09) v2(92.67,26.5) v2(92.8,7.45) v2(93.29,35.12) v2(93.36,19.77) v2(93.71,33.09) v2(94.07,7.45) v2(94.83,26.5) v2(94.96,38.57) v2(95.74,33.09) v2(95.97,7.45) v2(96.23,26.5) v2(96.56,22.17) v2(96.56,20.57) v2(96.76,33.09) v2(97.12,58.12) v2(97.36,19.77) v2(97.36,16.57) v2(98.13,7.45) v2(98.25,52.66) v2(98.15,22.17) v2(98.15,20.57) v2(98.15,19.77) v2(98.15,18.17) v2(98.15,14.17) v2(98.15,12.57) v2(98.15,10.97) v2(99.41,32.97) v2(101.31,13.8) v2(101.31,12.65) v2(101.31,11.51) v2(102.07,18.12) v2(102.07,15.96) v2(102.19,13.8) v2(102.19,12.65) v2(102.19,11.51) v2(103.08,13.8) v2(103.08,12.65) v2(103.08,11.51) v2(107.91,48.59) v2(108.51,48.59) v2(109.05,48.59) v2(109.18,10.37) v2(109.18,9.73) v2(109.18,9.1) v2(109.18,8.34) v2(118.2,13.67) v2(118.2,12.65) v2(118.2,11.64) v2(119.21,29.42) v2(119.21,28.78) v2(119.21,13.67) v2(119.21,12.65) v2(119.21,11.64) v2(119.62,29.11) v2(120.1,29.42) v2(120.1,28.78) v2(120.23,13.67) v2(120.23,12.65) v2(120.23,11.64) v2(121.24,29.44) v2(121.29,28.83) v2(121.75,29.14) v2(122.26,29.44) v2(122.26,28.86) v2(139.96,14.36) v2(141.34,14.28) v2(142.62,10.32) v2(143.11,17.74) v2(143.1,17.4) v2(146.15,19.42) v2(146.17,19.1) v2(146.18,18.75) v2(147.91,24.96) v2(148.93,24.96) v2(148.93,23.71) v2(149.95,24.96) v2(149.95,23.71) v2(151.06,23.5) v2(151.24,21.39) v2(153.45,66.4) v2(153.46,66.02) v2(154.02,66.38) v2(154,65.96) v2(155.67,23.58) v2(155.67,22.56) v2(158.2,59.26) v2(158.96,59.26) v2(159.03,50.45) v2(159.03,47.25) v2(159.03,44.05) v2(159.03,41.65) v2(159.03,37.65) v2(159.64,18.48) v2(159.73,59.26) v2(163.54,37.22) v2(164.68,36.81) v2(165.19,64.09) v2(165.19,63.2) v2(165.19,62.31) v2(165.95,64.09) v2(165.95,63.2) v2(165.95,62.31) v2(166.46,49.23) v2(166.46,46.82) v2(166.46,46.05) v2(166.58,57.23) v2(166.58,54.82) v2(166.96,64.09) v2(166.96,63.2) v2(166.96,62.31) v2(167.22,49.23) v2(167.22,46.82) v2(167.22,46.05) v2(167.35,57.23) v2(167.35,54.82) v2(167.38,29.39) v2(167.4,29.04) v2(167.41,28.67) v2(167.85,64.09) v2(167.85,63.2) v2(167.85,62.31) v2(167.98,57.23) v2(167.98,49.23) v2(167.98,46.82) v2(167.98,46.05) v2(168.11,54.82) v2(169.22,43.51) v2(169.25,42.93) v2(169.43,23.64) v2(169.5,61.39) v2(169.5,43.24) v2(169.73,43.51) v2(169.73,42.91) v2(169.91,46.99) v2(169.91,45.27) v2(170.34,22.38) v2(170.5,23.62) v2(170.55,22.1) v2(170.52,21.72) v2(170.91,39.37) v2(170.88,38.9) v2(171.4,39.37) v2(171.37,38.9) v2(171.81,39.38) v2(171.78,38.9) v2(173.8,38.56) v2(174.25,38.56) v2(174.63,38.56) v2(175.45,27.77) v2(175.42,26.47) v2(178.83,48.01) v2(179.3,55.73) v2(179.33,53.01) v2(179.33,49.37) v2(179.95,54.37) v2(180.35,47.96) v2(180.57,55.73) v2(180.57,53.01) v2(181.06,15.83) v2(182.48,49.37) v2(183.85,52.25) v2(183.86,15.83) v2(184.87,46.64) v2(185.35,52.25) v2(185.68,57.41) v2(185.65,56.27) v2(185.86,46) v2(186.9,56.82) v2(186.85,52.25) v2(188.17,57.43) v2(188.17,56.21) v2(188.19,49.99) v2(188.35,52.25) v2(189.85,52.25) v2(191.18,38.5) v2(191.2,37.49) v2(191.35,52.25) v2(191.54,44.78) v2(193.85,52.25) v2(195.64,49.28) v2(195.64,48.01) v2(195.64,45.47) v2(195.64,44.2) v2(195.64,42.93) v2(195.64,41.66) v2(195.64,40.39) v2(196.12,49.71) v2(196.61,45.7) v2(197.06,49.74) v2(197.51,57.23) v2(197.51,56.47) v2(197.88,46.11) v2(198.05,40.47) v2(198.37,56.82) v2(199.1,40.47) v2(199.17,57.23) v2(199.17,56.47) v2(199.48,49.74) v2(199.78,47.83) v2(199.78,46.51) v2(200.37,40.47) v2(201.38,49.74) v2(202.78,49.74) v2(202.96,45.56) v2(202.96,42.74) v2(204.91,53.55) v2(204.98,55.12) v2(205.32,54.48) v2(205.74,55.1) v2(205.72,53.55) v2(206.46,58.25) v2(206.46,57.87) v2(206.59,47.55) v2(206.58,46.18) v2(206.69,59.16) v2(206.74,58.12) v2(206.72,44.86) v2(206.79,46.41) v2(206.77,45.9) v2(207.1,58.25) v2(207.1,57.87) v2(207.68,60.96) v2(207.86,48.98) v2(207.86,47.71) v2(207.86,46.44) v2(207.86,45.17) v2(207.86,43.9) v2(207.86,42.63) v2(208.11,59.67) v2(219.54,31.33) v2(219.54,28.52) v2(219.62,17.76) v2(219.97,17.76) v2(220.35,17.76) v2(221.96,15.07) v2(222.08,30.13) v2(222.08,29.77) v2(222.08,29.42) v2(222.07,26.5) v2(222.08,25.43) v2(222.08,25.05) v2(222.08,24.69) v2(222.08,21.65) v2(222.08,21.26) v2(222.08,20.91) v3(3.63,14.33) v3(4.58,16.92) v3(6.23,13.97) v3(6.94,23.7) v3(6.92,22.56) v3(6.94,21.42) v3(6.94,20.27) v3(6.94,19.13) v3(12.35,42.91) v3(18.84,17.34) v3(18.86,17.74) v3(19.29,17.73) v3(19.29,17.35) v3(21.8,37.18) v3(22.82,11.13) v3(24.62,49.48) v3(24.62,48.98) v3(24.98,7.45) v3(24.98,6.94) v3(25.49,7.45) v3(25.49,6.94) v3(26.25,14.69) v3(26.25,13.54) v3(26.5,11.26) v3(26.76,17.48) v3(26.88,7.45) v3(28.53,44.84) v3(28.76,45.19) v3(32.21,18.24) v3(32.93,14.66) v3(33.81,47.65) v3(34.8,17.2) v3(34.96,50.17) v3(34.96,49.76) v3(34.96,49.38) v3(34.96,49) v3(34.96,48.52) v3(35.47,50.17) v3(35.47,49.76) v3(35.47,49.38) v3(35.47,49) v3(35.47,48.52) v3(35.92,47.76) v3(35.98,50.17) v3(35.98,49.76) v3(35.98,49.38) v3(35.98,49) v3(35.98,48.52) v3(36.36,50.17) v3(36.36,49.76) v3(36.36,49.38) v3(36.36,49) v3(36.48,48.52) v3(36.65,53.04) v3(36.65,52.02) v3(36.93,46.72) v3(37.81,50.63) v3(37.81,49.36) v3(38.59,40.56) v3(38.82,45.93) v3(38.82,45.55) v3(38.82,45.17) v3(39.04,13.58) v3(39.33,45.93) v3(39.33,45.55) v3(39.33,45.17) v3(39.71,45.93) v3(39.71,45.55) v3(39.71,45.17) v3(39.91,51.34) v3(39.96,60.54) v3(39.96,10.88) v3(39.96,8.84) v3(40.24,50.83) v3(40.22,45.93) v3(40.22,45.55) v3(40.22,45.17) v3(40.47,48.92) v3(40.73,55.3) v3(40.73,51.92) v3(40.73,51.54) v3(40.7,47.68) v3(40.73,47.27) v3(40.73,46.87) v3(40.75,56.57) v3(40.75,48.67) v3(40.88,57.05) v3(40.88,55.78) v3(40.88,54.51) v3(40.9,48.14) v3(41.03,56.57) v3(40.98,19.38) v3(41.1,60.41) v3(41.23,57.43) v3(41.23,56.16) v3(41.23,55.3) v3(41.23,54.89) v3(41.23,47.3) v3(41.28,53.07) v3(41.28,52.76) v3(41.28,52.4) v3(41.28,50.58) v3(41.28,50.22) v3(41.28,49.84) v3(41.26,48.52) v3(41.41,53.29) v3(41.49,41.36) v3(41.49,40.34) v3(41.87,58.37) v3(42.02,19.77) v3(42.02,19.26) v3(42.48,19.77) v3(42.48,19.26) v3(43.11,60.1) v3(43.22,42.47) v3(43.29,60.3) v3(43.39,59.97) v3(43.37,59.59) v3(43.77,61.8) v3(43.77,61.04) v3(44.03,65.99) v3(44.54,61.8) v3(44.54,61.04) v3(44.92,9.73) v3(45.17,61.8) v3(45.17,61.04) v3(45.68,17.77) v3(45.68,17.39) v3(45.68,17.01) v3(45.81,61.8) v3(45.81,61.04) v3(45.83,60.18) v3(46.09,60.41) v3(46.44,61.8) v3(46.44,61.04) v3(46.57,60) v3(46.92,60.48) v3(47.08,61.8) v3(47.08,61.04) v3(47.33,60.38) v3(47.36,60) v3(47.71,61.8) v3(47.71,61.04) v3(48.07,60.28) v3(48.07,59.97) v3(48.35,61.8) v3(48.35,61.04) v3(48.98,61.8) v3(48.98,61.04) v3(49.01,59.97) v3(49.34,60.48) v3(49.62,61.8) v3(49.62,61.04) v3(49.87,60.38) v3(50.25,61.8) v3(50.25,61.04) v3(50.33,59.97) v3(50.89,61.8) v3(50.89,61.04) v3(51.52,61.8) v3(51.52,61.04) v3(51.83,42.07) v3(51.83,41.66) v3(52.16,61.8) v3(52.16,61.04) v3(52.23,41.66) v3(52.33,42.07) v3(52.29,13.92) v3(52.54,17.81) v3(52.59,37.14) v3(52.59,36.73) v3(52.79,61.8) v3(52.79,61.04) v3(52.82,18.02) v3(52.82,17.62) v3(52.99,37.14) v3(52.99,36.73) v3(53.48,43.59) v3(53.48,43.18) v3(53.81,60.53) v3(53.81,60.02) v3(53.88,43.59) v3(53.88,43.18) v3(54.06,67.26) v3(54.06,66.76) v3(54.19,60.53) v3(54.19,60.02) v3(54.57,67.01) v3(54.95,59.77) v3(55.08,67.26) v3(55.08,66.76) v3(55.84,63.83) v3(55.84,63.33) v3(55.79,60.53) v3(55.79,60.02) v3(56.09,67.39) v3(56.09,66.88) v3(56.17,60.53) v3(56.17,60.02) v3(56.35,67.11) v3(56.35,63.58) v3(56.4,44.73) v3(56.4,44.33) v3(56.6,67.39) v3(56.6,66.88) v3(56.8,44.73) v3(56.8,44.33) v3(56.86,63.83) v3(56.86,63.33) v3(56.96,60.53) v3(56.96,60.02) v3(57.34,60.53) v3(57.34,60.02) v3(57.74,63.2) v3(58.13,60.53) v3(58.13,60.02) v3(58.25,63.2) v3(58.51,60.53) v3(58.51,60.02) v3(58.58,38.51) v3(58.58,38.1) v3(58.61,35.67) v3(58.61,35.26) v3(58.99,38.51) v3(58.99,38.1) v3(59.01,35.67) v3(59.01,35.26) v3(59.29,60.53) v3(59.29,60.02) v3(59.28,16.08) v3(59.45,44.73) v3(59.45,44.33) v3(59.59,65.79) v3(59.59,65.29) v3(59.59,64.78) v3(59.67,60.53) v3(59.67,60.02) v3(59.85,44.73) v3(59.85,44.33) v3(60.13,65.79) v3(60.13,65.29) v3(60.13,64.78) v3(60.64,59.77) v3(60.67,65.79) v3(60.67,65.28) v3(60.67,64.77) v3(60.66,16.08) v3(61.53,67.25) v3(61.53,66.75) v3(61.53,66.24) v3(61.5,60.53) v3(61.5,60.02) v3(61.88,60.53) v3(61.88,60.02) v3(62.07,67.25) v3(62.07,66.75) v3(62.07,66.24) v3(62.61,67.25) v3(62.61,66.74) v3(62.61,66.23) v3(62.67,60.53) v3(62.67,60.02) v3(63.05,60.53) v3(63.05,60.02) v3(63.84,17.48) v3(65.11,58.63) v3(65.24,57.48) v3(65.24,56.98) v3(65.31,45.04) v3(65.62,57.48) v3(65.62,56.98) v3(66.37,60.28) v3(66.63,57.23) v3(67.14,14.69) v3(67.27,10.85) v3(67.27,10.39) v3(67.37,45.03) v3(67.65,40.59) v3(67.78,10.85) v3(67.78,10.39) v3(68.54,43.81) v3(68.67,46.17) v3(69.05,60.16) v3(69.3,9.2) v3(69.56,43.81) v3(69.68,46.17) v3(70.27,58.09) v3(70.32,56.86) v3(70.45,41.18) v3(70.57,43.81) v3(70.57,12.63) v3(70.57,11.49) v3(70.57,10.47) v3(70.7,46.17) v3(70.7,9.2) v3(70.83,60.02) v3(71.46,57.61) v3(71.71,46.17) v3(71.71,42.12) v3(71.71,41.1) v3(71.71,34.88) v3(71.71,30.96) v3(71.78,7.62) v3(71.89,43.26) v3(71.97,57.61) v3(73.1,55.71) v3(73.1,54.69) v3(73.1,53.67) v3(73.1,50.5) v3(73.62,44.01) v3(73.87,52.66) v3(73.88,49.48) v3(74.13,56.85) v3(74.13,36.92) v3(74.26,48.47) v3(74.26,47.45) v3(74.49,46.18) v3(74.64,56.85) v3(75.55,30.93) v3(76.03,50.75) v3(76.03,39.71) v3(76.17,54.44) v3(76.16,19) v3(76.36,52.1) v3(76.36,51.72) v3(76.67,49.86) v3(76.67,49.36) v3(76.67,46.55) v3(76.87,52.07) v3(76.87,51.72) v3(76.93,17.99) v3(77.18,60.15) v3(77.3,44.92) v3(78.6,50.5) v3(78.72,34.57) v3(80.65,50.5) v3(81.62,16.59) v3(82.52,59.52) v3(82.52,58.5) v3(83.27,45.29) v3(83.78,13.67) v3(83.91,49.36) v3(85.68,7.17) v3(86.45,12.27) v3(86.45,10.24) v3(86.95,7.29) v3(86.95,6.91) v3(87.34,7.29) v3(87.34,6.91) v3(88.48,16.31) v3(89.24,41.61) v3(89.49,53.32) v3(89.49,52.81) v3(89.49,51.13) v3(89.49,50.63) v3(89.49,10.62) v3(89.82,55.43) v3(90.21,56.32) v3(90.21,55.81) v3(90.33,55.43) v3(90.64,51.01) v3(90.64,50.5) v3(90.76,52.65) v3(90.76,52.14) v3(90.87,56.29) v3(90.87,55.81) v3(90.87,55.43) v3(91.35,56.29) v3(91.35,55.81) v3(91.35,55.43) v3(91.53,51.01) v3(91.53,50.5) v3(91.65,52.65) v3(91.65,52.14) v3(91.86,56.29) v3(91.86,55.81) v3(91.86,55.43) v3(92.54,38.55) v3(92.91,29.67) v3(92.91,28.66) v3(93.81,31.71) v3(94.96,13.36) v3(95.23,13.36) v3(95.35,46.05) v3(95.72,25.48) v3(96.1,28.78) v3(96.1,28.15) v3(96.1,27.51) v3(96.1,26.75) v3(96.61,28.78) v3(96.61,28.15) v3(96.61,27.51) v3(96.61,26.75) v3(96.99,25.48) v3(97.24,50.25) v3(97.16,29.98) v3(97.61,53.67) v3(98.38,14.56) v3(98.38,13.8) v3(98.64,50.5) v3(98.64,49.99) v3(98.61,14.15) v3(98.89,28.79) v3(98.89,14.56) v3(98.89,13.8) v3(98.99,33.3) v3(99.27,50.5) v3(99.27,49.99) v3(99.53,53.56) v3(99.65,47.06) v3(99.78,26.88) v3(99.91,50.5) v3(99.91,49.99) v3(100.3,17.58) v3(100.54,53.56) v3(100.54,50.5) v3(100.54,49.99) v3(100.92,30.89) v3(101.18,44.01) v3(102.32,29.8) v3(102.58,52.66) v3(102.68,41.71) v3(103.09,50.12) v3(103.34,44.02) v3(104.48,36.53) v3(104.48,35.26) v3(104.48,33.99) v3(104.48,32.72) v3(104.87,37.61) v3(105.5,41.61) v3(105.72,37.58) v3(105.75,36.53) v3(105.73,35.26) v3(105.75,33.99) v3(105.75,32.72) v3(106.31,49.97) v3(106.31,49.46) v3(106.44,43.99) v3(106.51,41.36) v3(106.66,49.74) v3(106.94,49.97) v3(106.94,49.46) v3(106.99,37.58) v3(107.02,36.53) v3(107,35.26) v3(107.02,33.99) v3(107.02,32.72) v3(107.53,41.36) v3(108.26,37.58) v3(108.29,36.53) v3(108.27,35.26) v3(108.29,33.99) v3(108.29,32.72) v3(108.67,43.64) v3(108.67,43.13) v3(108.67,42.63) v3(108.67,41.86) v3(109.43,43.64) v3(109.43,43.13) v3(109.43,42.63) v3(109.53,37.58) v3(109.54,35.26) v3(109.56,36.53) v3(109.56,33.99) v3(109.56,32.72) v3(110.32,45.93) v3(110.32,45.42) v3(110.32,44.78) v3(111.21,45.93) v3(111.21,45.42) v3(111.21,44.78) v3(111.8,39.7) v3(111.8,39.15) v3(112.02,39.43) v3(112.23,36.41) v3(112.25,39.7) v3(112.25,39.15) v3(112.94,38.23) v3(112.94,37.67) v3(112.89,20.61) v3(113.11,20.28) v3(113.17,37.95) v3(113.4,38.23) v3(113.4,37.67) v3(113.4,36.91) v3(113.4,36.35) v3(113.62,36.63) v3(113.85,36.91) v3(113.85,36.35) v3(114.01,42.37) v3(114.26,38.75) v3(114.51,42.37) v3(115.39,36.83) v3(115.39,35.82) v3(116.53,11.82) v3(116.55,14.15) v3(116.55,13.03) v3(117.16,18.14) v3(117.33,18.47) v3(119.72,48.34) v3(119.87,41.23) v3(120.74,49.13) v3(120.86,45.54) v3(121.4,32.16) v3(121.4,31.81) v3(121.4,31.5) v3(122.01,45.53) v3(122.11,49.36) v3(122.11,48.85) v3(122.51,52.64) v3(122.72,49.34) v3(122.72,48.83) v3(123.15,54.18) v3(123.15,45.54) v3(123.33,60.78) v3(123.5,49.36) v3(123.5,48.85) v3(123.66,52.63) v3(123.79,37.47) v3(123.94,54.72) v3(124.14,49.36) v3(124.14,48.85) v3(124.08,35.02) v3(124.29,45.53) v3(124.29,34.7) v3(124.5,34.42) v3(125.31,45.54) v3(125.44,40.09) v3(125.69,52.67) v3(126.46,47.71) v3(126.65,39.07) v3(126.7,43.14) v3(126.7,40.09) v3(126.93,64.83) v3(126.93,64.24) v3(127.16,64.52) v3(127.39,64.83) v3(127.39,64.24) v3(128.21,60.13) v3(128.31,65.69) v3(129.16,38.37) v3(129.16,38.11) v3(129.16,37.85) v3(129.46,38.56) v3(129.63,26.37) v3(129.76,38.56) v3(130.02,38.55) v3(130.01,26.37) v3(130.13,45.17) v3(130.46,65.77) v3(130.67,66.1) v3(130.9,66.43) v3(131.66,38.08) v3(131.67,22.18) v3(131.67,21.04) v3(131.91,59.53) v3(132.01,38.07) v3(132.37,38.05) v3(132.8,34.12) v3(133.41,12.83) v3(133.41,12.45) v3(133.41,12.12) v3(133.46,44) v3(133.64,17.07) v3(133.99,17.07) v3(134.1,62.31) v3(134.33,66.26) v3(135.34,66.26) v3(135.47,49.47) v3(135.62,15.22) v3(135.62,14.84) v3(135.62,14.51) v3(135.95,36.5) v3(136.36,66.26) v3(136.51,57.48) v3(136.51,56.98) v3(137.01,57.98) v3(137.01,57.48) v3(137.01,56.98) v3(137.01,56.48) v3(137.25,40.75) v3(137.37,66.26) v3(137.37,41.88) v3(137.63,56.98) v3(137.55,39.33) v3(137.88,63.97) v3(138.14,56.98) v3(138.39,66.26) v3(138.52,34.36) v3(139.47,41.52) v3(140.55,64.19) v3(140.95,18.6) v3(141.44,21.42) v3(141.82,48.1) v3(141.89,21.42) v3(142.03,42.86) v3(142.01,18.61) v3(142.2,64.35) v3(142.21,41.51) v3(142.91,21.39) v3(142.91,18.65) v3(143.12,50.59) v3(143.92,41.53) v3(143.9,18.6) v3(144.74,63.96) v3(144.86,18.59) v3(145,55.2) v3(145.19,49.29) v3(145.6,58.63) v3(146.24,19) v3(146.77,18.98) v3(147.25,18.98) v3(148.16,42.37) v3(148.52,49.48) v3(148.75,18.95) v3(149.17,49.48) v3(149.82,49.48) v3(150.45,47.71) v3(150.45,46.69) v3(150.45,58.76) v3(150.47,49.48) v3(151.34,43.27) v3(151.98,34.5) v3(152.11,43.9) v3(152.36,34.5) v3(152.49,43.9) v3(152.87,43.9) v3(153.04,35.74) v3(153.07,49.48) v3(153.38,44.28) v3(153.38,43.9) v3(153.5,57.98) v3(153.72,49.48) v3(153.96,24.62) v3(153.96,23.35) v3(154.3,24.6) v3(154.53,42.37) v3(154.62,18.98) v3(154.72,24.67) v3(155.02,55.58) v3(155.02,49.48) v3(154.98,18.98) v3(155.16,47.71) v3(155.16,46.69) v3(155.18,24.67) v3(155.38,18.98) v3(155.56,24.67) v3(155.7,60.26) v3(155.76,18.98) v3(155.95,40.95) v3(156.02,24.67) v3(156.17,18.98) v3(156.55,58.76) v3(156.55,18.98) v3(156.91,18.98) v3(157.3,46.44) v3(157.3,45.42) v3(157.31,18.98) v3(157.69,18.98) v3(158.1,18.98) v3(159.6,58.76) v3(159.65,24.9) v3(159.65,24.57) v3(159.65,24.16) v3(159.66,46.68) v3(160.36,46.56) v3(160.36,45.93) v3(160.36,45.29) v3(160.87,46.56) v3(160.87,45.93) v3(160.87,45.29) v3(161.48,37.45) v3(162.77,43.39) v3(163.67,47.45) v3(163.67,45.42) v3(164.68,41.24) v3(165.31,38.05) v3(165.31,37.55) v3(165.54,33.18) v3(165.54,32.85) v3(165.69,41.85) v3(165.93,38.03) v3(165.93,37.53) v3(165.87,33.18) v3(166.33,39.91) v3(166.33,39.55) v3(166.71,41.85) v3(166.71,38.05) v3(166.71,37.55) v3(167.17,33.2) v3(167.35,38.05) v3(167.35,37.55) v3(167.55,33.23) v3(167.73,41.24) v3(167.95,33.23) v3(168.09,28.8) v3(168.09,26.51) v3(168.54,49.92) v3(168.46,48.57) v3(169.33,10.75) v3(169.33,10.37) v3(169.66,35.51) v3(169.71,15.63) v3(169.71,15.12) v3(169.68,10.75) v3(169.68,10.37) v3(170.04,35.51) v3(170.13,32.6) v3(170.09,10.75) v3(170.09,10.37) v3(170.16,27.5) v3(170.16,25.21) v3(170.44,35.51) v3(170.65,10.72) v3(170.62,10.37) v3(171,10.72) v3(170.98,10.37) v3(171.41,10.72) v3(171.38,10.37) v3(172.78,27.72) v3(172.94,65.49) v3(172.98,15.85) v3(172.98,15.55) v3(173.16,27.72) v3(173.36,15.85) v3(173.36,15.55) v3(173.57,27.72) v3(173.77,15.85) v3(173.77,15.55) v3(174.18,26.26) v3(174.25,33.43) v3(174.63,33.43) v3(175.04,33.38) v3(175.73,12.91) v3(175.73,12.27) v3(176.24,12.91) v3(176.24,12.27) v3(176.26,24.96) v3(176.4,19.47) v3(176.62,12.91) v3(176.62,12.27) v3(176.87,28.75) v3(179.55,21.26) v3(180.16,19.48) v3(180.89,19.49) v3(186.01,55.96) v3(186.01,55.33) v3(186.27,55.65) v3(186.52,55.96) v3(186.52,55.33) v3(186.78,54.18) v3(187.15,45.8) v3(187.54,52.79) v3(187.92,44.29) v3(188.55,57.23) v3(189.34,44.91) v3(189.34,44.4) v3(189.32,40.97) v3(189.95,48.88) v3(190.05,44.91) v3(190.05,44.4) v3(190.33,40.97) v3(190.31,26.37) v3(190.31,25.86) v3(190.69,44.91) v3(190.69,44.4) v3(190.97,48.88) v3(190.99,30.38) v3(191.3,44.94) v3(191.3,44.4) v3(191.35,40.97) v3(191.37,30.38) v3(191.78,30.38) v3(192.11,50.88) v3(192.19,30.38) v3(192.26,26.37) v3(192.26,25.86) v3(192.57,30.38) v3(192.97,30.38) v3(193.52,45.93) v3(194.37,59.62) v3(194.37,58.91) v3(194.61,47.43) v3(194.93,47.2) v3(195.25,46.93) v3(195.53,45.93) v3(195.67,43.51) v3(197.1,62.44) v3(197.29,66.68) v3(197.29,66.04) v3(197.44,52.02) v3(197.55,66.35) v3(197.83,66.68) v3(197.83,66.02) v3(198.97,49.13) v3(199.15,52.28) v3(199.15,51.9) v3(199.5,52.28) v3(199.5,51.9) v3(199.88,52.28) v3(199.88,51.9) v3(199.98,49.13) v3(200.24,64.71) v3(200.53,62.44) v3(201.38,65.49) v3(201.39,54.44) v3(201.94,49.94) v3(201.94,49.51) v3(202.35,49.94) v3(202.35,49.48) v3(203.29,49.11) v3(203.36,50.75) v3(203.36,50.32) v3(203.67,64.33) v3(203.79,56.73) v3(203.77,50.75) v3(203.77,50.3) v3(206.51,59.75) v3(207.25,61.02) v3(207.86,48.32) v3(207.86,47.83) v3(207.86,47.39) v3(208.62,65.86) v3(219.55,16.08) v3(221.33,17.1) v4(39.91,51.34) v4(40.24,50.83) v4(40.47,48.92) v4(40.73,51.92) v4(40.73,51.54) v4(40.7,47.68) v4(40.73,47.27) v4(40.75,56.57) v4(40.75,48.67) v4(41.03,56.57) v4(41.28,53.07) v4(41.28,52.76) v4(41.28,52.4) v4(41.28,50.58) v4(41.28,50.22) v4(41.28,49.84) v4(41.41,53.29) v4(43.11,60.1) v4(43.22,42.47) v4(43.29,60.3) v4(43.39,59.97) v4(43.37,59.59) v4(45.83,60.18) v4(46.09,60.41) v4(46.57,60) v4(46.92,60.48) v4(47.33,60.38) v4(47.25,42.5) v4(47.36,60) v4(48.07,60.28) v4(48.07,59.97) v4(48.24,41) v4(49.01,59.97) v4(49.34,60.48) v4(49.54,39.27) v4(49.51,37.98) v4(49.87,60.38) v4(49.92,43.06) v4(49.87,41.51) v4(50.33,59.97) v4(52.33,42.07) v4(52.77,42.96) v4(54.44,40.09) v4(55.23,43.9) v4(57.21,45.52) v4(58.66,45.37) v4(59.01,44.3) v4(59.14,41.76) v4(59.59,65.79) v4(59.59,65.29) v4(59.59,64.78) v4(60.13,65.79) v4(60.13,65.29) v4(60.13,64.78) v4(60.67,65.79) v4(60.67,65.28) v4(60.67,64.77) v4(61.53,67.25) v4(61.53,66.75) v4(61.53,66.24) v4(62.07,67.25) v4(62.07,66.75) v4(62.07,66.24) v4(62.61,67.25) v4(62.61,66.74) v4(62.61,66.23) v4(108.67,43.64) v4(108.67,43.13) v4(108.67,42.63) v4(109.43,43.64) v4(109.43,43.13) v4(109.43,42.63) v4(134.1,62.31) v4(153.96,23.35) v4(155.72,45.01) v4(157.31,44.99) v4(176.4,19.47) v4(179.55,21.26) v4(180.16,19.48) v4(180.91,21.85) v4(180.89,19.49) v4(194.37,59.62) v4(194.37,58.91) v4(206.51,59.75) v4(207.25,61.02) v5(12.76,15.52) v5(13.4,9.17) v5(13.9,16.13) v5(14.16,17.3) v5(14.82,25.61) v5(14.79,12.93) v5(14.77,12.07) v5(15.05,20.73) v5(15.3,23.02) v5(15.3,16.79) v5(15.45,18.29) v5(15.5,13.87) v5(15.53,7.62) v5(16.19,16.29) v5(16.47,27) v5(16.6,14.46) v5(16.9,8.49) v5(17.69,7.14) v5(17.79,16.87) v5(18.12,28.66) v5(18.98,16.95) v5(19.52,7.01) v5(21.85,32.49) v5(23.33,33.99) v5(26.55,37.44) v5(27.95,38.59) v5(29.42,6.86) v5(30.11,38.71) v5(30.64,6.86) v5(32.37,6.79) v5(34.78,6.84) v5(36,42.7) v5(37.42,6.84) v5(40.35,47.6) v5(41.77,50.65) v5(42.17,45.95) v5(42.33,61.45) v5(43.06,45.95) v5(43.9,64.09) v5(43.95,62.26) v5(43.95,45.95) v5(43.95,42.4) v5(44.71,45.95) v5(44.92,63.58) v5(44.92,43.87) v5(45.24,7.31) v5(45.6,44.68) v5(45.93,41.33) v5(46.44,45.93) v5(46.82,42.47) v5(47.2,45.93) v5(48.02,45.95) v5(49.11,45.9) v5(49.36,64.72) v5(49.36,63.58) v5(50,60.08) v5(50.61,7.9) v5(50.81,10.32) v5(51.65,45.9) v5(52.54,45.9) v5(52.49,17.81) v5(52.51,16.97) v5(53.02,7.9) v5(53.15,19.21) v5(53.27,17.17) v5(53.27,11.26) v5(53.27,9.4) v5(53.43,45.9) v5(53.78,17.68) v5(53.98,13.77) v5(54.04,13.06) v5(54.01,12.17) v5(54.32,45.9) v5(54.49,15.45) v5(55.69,9.43) v5(55.69,7.9) v5(56.75,6.89) v5(57.72,10.32) v5(57.77,16.29) v5(58.1,7.9) v5(58.35,12.6) v5(58.56,13.7) v5(58.63,11.21) v5(58.76,6.96) v5(59.22,14.74) v5(59.45,12.2) v5(59.78,67.24) v5(59.88,7.9) v5(60.13,16.79) v5(60.23,14.43) v5(60.69,67.23) v5(61.4,14.38) v5(62.29,7.9) v5(62.65,43.03) v5(64.98,44.61) v5(70.93,6.76) v5(72.04,42.52) v5(73.85,8.79) v5(73.87,6.81) v5(75.5,6.76) v5(80.73,36.4) v5(81.87,35.64) v5(83.14,35.01) v5(83.14,6.81) v5(83.96,34.22) v5(84.62,6.79) v5(93.81,12.02) v5(94.02,8.03) v5(94.83,9.05) v5(94.85,10.72) v5(96.07,10.77) v5(96.35,8.72) v5(97.5,16.84) v5(97.72,10.98) v5(97.83,13.77) v5(97.83,12.27) v5(97.8,7.37) v5(98.38,15.45) v5(98.38,8.72) v5(154.65,25.07) v5(167.9,48.54) v5(170.75,46.13) v5(176.4,47.07) v5(176.44,43.13) v5(177.82,47.41) v5(177.96,43.16) v5(196.17,45.93) v5(198.21,45.88) v5(199.4,47.81) v5(206.21,47.6) v5(206.21,46.16) v5(206.38,44.66) v5(206.89,60.74) v5(206.92,59.64) v5(207.17,45.88) v6(0.77,16.79) v6(0.77,14.25) v6(0.77,11.71) v6(0.77,9.17) v6(0.77,6.63) v6(1.1,5.87) v6(1.89,18.24) v6(3.18,15.3) v6(3.31,5.87) v6(4,18.22) v6(4.91,24.08) v6(5.32,22.31) v6(5.5,19.59) v6(5.67,26.17) v6(6.33,28.55) v6(6.92,31.45) v6(7.22,57.48) v6(7.22,54.94) v6(7.22,52.4) v6(7.22,49.86) v6(7.22,47.32) v6(7.22,44.02) v6(7.22,42.24) v6(7.22,39.7) v6(7.22,37.16) v6(7.22,34.62) v6(8.04,5.87) v6(8.26,27.69) v6(10.78,6.94) v6(11.21,68.13) v6(11.21,67.11) v6(11.21,65.16) v6(12.74,13.05) v6(12.66,8.28) v6(12.79,11.64) v6(12.91,23.45) v6(12.91,22.05) v6(12.91,20.53) v6(12.91,18.44) v6(12.91,17.1) v6(14.61,68.1) v6(14.95,66.1) v6(15.48,38.38) v6(15.53,6.18) v6(16.16,42.07) v6(16.42,66.4) v6(16.6,11.71) v6(17.21,61.75) v6(17.26,16.46) v6(17.36,18.19) v6(17.61,14.38) v6(17.87,12.22) v6(18.07,6.18) v6(19.06,66.43) v6(20.61,6.18) v6(21.37,17.99) v6(21.96,19.31) v6(23.15,6.18) v6(23.56,68.13) v6(25.69,6.18) v6(26.1,68.13) v6(28.23,6.18) v6(28.64,68.13) v6(30.29,61.68) v6(30.77,6.18) v6(31.18,68.13) v6(33.31,6.18) v6(33.72,68.13) v6(34.2,19.79) v6(34.15,17.94) v6(35.85,6.18) v6(36.26,68.13) v6(38.39,6.18) v6(38.8,68.13) v6(40.93,6.18) v6(43.47,6.18) v6(43.7,17.99) v6(43.88,68.13) v6(44.74,19.11) v6(46.01,6.18) v6(46.42,68.13) v6(47.33,47.2) v6(48.35,47.2) v6(48.55,6.18) v6(48.96,68.13) v6(49.36,47.2) v6(49.97,6.89) v6(50.25,12.2) v6(50.38,47.2) v6(50.53,18.11) v6(50.99,17.33) v6(51.39,47.2) v6(51.39,10.75) v6(51.5,68.13) v6(51.5,6.89) v6(52.41,47.2) v6(53.43,47.2) v6(53.63,6.18) v6(54.04,68.13) v6(54.44,47.2) v6(54.98,43.16) v6(55.22,41.47) v6(55.22,39.41) v6(55.84,14.56) v6(55.84,12.91) v6(55.84,10.88) v6(55.86,44.4) v6(56.17,6.18) v6(56.58,68.13) v6(57.62,13.49) v6(57.62,11.71) v6(58.73,67.24) v6(58.71,6.18) v6(59.01,9.71) v6(59.12,68.13) v6(60.36,6.84) v6(61.02,18.27) v6(61.25,6.18) v6(61.35,16.72) v6(61.43,9.68) v6(61.66,68.13) v6(62.32,6.89) v6(63.79,6.18) v6(63.92,68.15) v6(63.89,54.11) v6(63.89,53.09) v6(63.89,52.07) v6(63.89,51.06) v6(63.89,50.04) v6(63.89,49.03) v6(63.89,48.01) v6(65.16,17.99) v6(66,70.21) v6(66.33,18.93) v6(66.33,6.18) v6(68.87,6.18) v6(71.41,6.18) v6(73.37,70.21) v6(73.95,6.18) v6(74.79,68.81) v6(76.49,6.18) v6(76.9,68.13) v6(79.03,6.18) v6(79.44,68.13) v6(79.56,19.61) v6(79.64,17.76) v6(81.57,6.18) v6(81.98,68.13) v6(84.11,6.18) v6(84.52,68.13) v6(86.65,6.18) v6(86.77,36.03) v6(86.77,34.38) v6(86.77,32.73) v6(87.06,68.13) v6(87.51,17.94) v6(88.04,36.03) v6(88.04,34.38) v6(88.04,32.73) v6(88.55,19.11) v6(89.19,6.18) v6(89.31,36.03) v6(89.31,34.38) v6(89.31,32.73) v6(89.6,68.13) v6(91.73,6.18) v6(92.14,68.13) v6(94.04,18.17) v6(94.24,35.87) v6(94.27,6.18) v6(94.68,68.13) v6(94.93,17.12) v6(94.98,6.86) v6(96.81,6.18) v6(97.04,6.86) v6(97.22,68.13) v6(97.37,65.74) v6(98,65.74) v6(99.35,6.18) v6(99.76,68.13) v6(101.89,6.18) v6(102.3,68.13) v6(103.92,6.18) v6(104.84,68.13) v6(107.38,68.13) v6(109.03,67.06) v6(109.59,19.66) v6(109.92,68.13) v6(110.22,67.06) v6(111.52,15.6) v6(111.72,11.51) v6(111.77,44.97) v6(111.77,44.23) v6(111.85,17.86) v6(112.46,68.13) v6(113.67,31.2) v6(113.67,30.43) v6(114.13,11.64) v6(115,68.13) v6(117.54,68.13) v6(117.64,6.18) v6(119.06,37.34) v6(119.06,36.66) v6(119.67,6.18) v6(119.82,37.34) v6(119.82,36.66) v6(120.41,66.4) v6(123.17,66.48) v6(124.65,6.58) v6(125.16,68.13) v6(127.57,68.18) v6(127.98,66.68) v6(128.53,7.07) v6(129.83,6.18) v6(130.24,68.18) v6(131.76,65.05) v6(132.37,6.18) v6(132.78,68.18) v6(134.91,6.18) v6(135.32,68.18) v6(136.33,16.34) v6(137.45,6.18) v6(137.75,15.07) v6(137.78,12.96) v6(137.86,68.18) v6(139.3,10.8) v6(139.99,6.18) v6(140.4,68.18) v6(141.39,12.2) v6(142.94,68.13) v6(145.15,6.18) v6(145.48,68.13) v6(147.28,14.05) v6(147.63,68.13) v6(147.69,6.18) v6(148.68,14.05) v6(150.17,68.13) v6(150.2,14.05) v6(150.23,6.18) v6(150.96,39.45) v6(150.96,38.69) v6(151.75,39.45) v6(151.72,38.66) v6(151.98,14.69) v6(152.71,68.13) v6(152.82,10.93) v6(152.77,6.18) v6(153.5,14.69) v6(153.99,28.31) v6(155.25,68.13) v6(155.28,14.69) v6(155.31,6.18) v6(155.48,10.93) v6(156.98,24.79) v6(157.01,23.19) v6(157.79,68.13) v6(157.85,6.18) v6(160.33,68.13) v6(160.39,6.18) v6(162.87,68.13) v6(162.93,6.18) v6(165.41,68.13) v6(165.44,6.23) v6(167.95,68.13) v6(168.01,6.18) v6(170.49,68.13) v6(170.55,6.18) v6(171.23,15.47) v6(171.99,49.29) v6(173.03,68.13) v6(173.09,6.18) v6(173.87,6.96) v6(174.53,6.96) v6(175.57,68.13) v6(175.63,6.18) v6(178.11,68.13) v6(178.17,6.18) v6(180.65,68.13) v6(180.71,6.18) v6(181.67,37.74) v6(181.67,36.85) v6(183.19,68.13) v6(183.25,6.18) v6(185.73,68.13) v6(185.79,6.18) v6(188.27,68.13) v6(188.33,6.18) v6(190.81,68.13) v6(190.87,6.18) v6(193.35,68.13) v6(193.38,40.29) v6(193.41,6.18) v6(193.71,21.04) v6(194.42,21.06) v6(195.39,34.47) v6(195.89,68.13) v6(195.95,6.18) v6(196.61,43.9) v6(196.56,40.59) v6(197.32,40.59) v6(197.27,22.97) v6(197.29,22.31) v6(198.43,68.13) v6(198.49,6.18) v6(198.69,29.95) v6(198.66,27.31) v6(199.22,45.67) v6(199.25,44.56) v6(199.73,45.04) v6(200.31,45.65) v6(200.34,44.61) v6(200.64,26.7) v6(200.97,68.13) v6(201.03,6.18) v6(201.25,35.26) v6(201.89,35.26) v6(202.02,40.47) v6(202.02,21.26) v6(202.02,20.38) v6(202.02,19.49) v6(202.73,24.69) v6(202.65,17.35) v6(202.75,24.03) v6(203.51,68.13) v6(203.57,6.18) v6(203.67,60.79) v6(204.3,62.44) v6(204.43,60.79) v6(204.63,41.99) v6(204.63,41.36) v6(204.56,40.47) v6(205.09,58.83) v6(205.27,41.99) v6(205.27,41.33) v6(205.52,68.43) v6(205.57,63.61) v6(205.57,49.74) v6(206.11,6.18) v6(206.21,40.47) v6(206.56,32.03) v6(207.02,54.36) v6(207.22,49.74) v6(207.76,69.93) v6(208.49,6.46) v6(209.64,10.75) v6(209.64,8.51) v6(209.76,12.48) v6(211.49,28.81) v6(212.43,38.38) v6(212.68,16.51) v6(212.81,55.05) v6(213.95,55.02) v6(213.95,37.55) v6(213.95,36.91) v6(214.06,66.27) v6(214.16,57.31) v6(214.28,65.1) v6(214.28,62.56) v6(214.28,60.02) v6(214.46,69.68) v6(214.46,38.38) v6(214.59,37.55) v6(214.59,36.91) v6(215.45,54.56) v6(216.49,38.87) v6(216.5,9.49) v6(216.9,69.75) v6(216.88,23.66) v6(216.88,20.88) v6(217,54.51) v6(217.13,37.72) v6(217.81,9.48) v6(217.89,11.84) v6(217.97,56.77) v6(218.25,67.04) v6(218.3,69.93) v6(218.6,22.66) v6(220.35,56.77) v6(220.89,12.83) v6(221.02,37.44) v6(221.24,54.51) v6(221.32,38.87) v6(221.68,69.93) v6(222.51,37.09) v6(222.51,34.9) v6(222.67,9.48) v6(223.63,33.05) v6(223.63,30.84) v6(223.71,23.37) v6(223.71,12.07) v6(223.78,27.92) v6(223.86,54.51) v6(224.19,68.61) v6(224.22,67.19) v6(224.22,56.54) v7(18.2,17.3) v7(21.4,42.68) v7(45.68,62.44) v7(51.8,62.36) v7(59.93,66.7) v7(65.44,68.18) v7(85.1,33.43) v7(88.66,67.16) v7(90.79,35.21) v7(97.55,65.03) v7(102.16,23.62) v7(109.61,67.47) v7(110.17,44.23) v7(113.24,42.6) v7(122.23,30.61) v7(125.56,39.07) v7(131.45,65.94) v7(138.67,32.08) v7(141.16,6.84) v7(161.2,34.78) v7(171.43,39.98) v7(171.89,10.06) v7(195.36,21.32) v7(202.04,24.21) v7(202.47,35.69) v7(202.75,16.59) v7(204.96,42.65) v7(213.29,56.16) v7(215.33,68.31) v8(142.62,10.32) v8(207.68,60.96) v8(208.11,59.67) v9(43.22,42.47) v9(155.72,45.01) v9(157.31,44.99) v9(179.55,21.26) v9(206.51,59.75) v9(207.25,61.02) v10(7.55,9.66) v10(7.55,8.92) v10(7.58,8.18) v10(7.93,58.25) v10(7.93,57.51) v10(8.21,29.93) v10(8.29,10.39) v10(8.29,9.66) v10(8.29,8.92) v10(8.32,8.18) v10(8.39,52.46) v10(8.39,51.69) v10(8.42,50.88) v10(8.42,50.12) v10(9.03,10.39) v10(9.03,9.66) v10(9.03,8.92) v10(9.13,52.46) v10(9.13,51.69) v10(9.1,43.01) v10(9.1,41.1) v10(9.1,39.2) v10(9.05,8.18) v10(9.15,50.88) v10(9.15,50.12) v10(9.89,52.46) v10(9.89,51.69) v10(9.92,50.88) v10(9.92,50.12) v10(10.65,52.46) v10(10.65,51.69) v10(10.68,50.88) v10(10.68,50.12) v10(11.31,62.51) v10(11.31,61.75) v10(11.41,52.46) v10(11.41,51.69) v10(11.44,50.88) v10(11.44,50.12) v10(12.15,53.27) v10(12.18,52.46) v10(12.18,51.69) v10(12.2,50.88) v10(12.2,50.12) v10(13.17,54.31) v10(13.17,53.29) v10(13.93,54.31) v10(13.93,53.29) v10(14.69,54.31) v10(14.69,53.29) v10(15.45,54.31) v10(15.45,53.29) v10(15.81,62.49) v10(16.22,54.31) v10(21.88,50.55) v10(21.93,43.26) v10(22.64,50.55) v10(22.69,43.26) v10(23.38,50.55) v10(23.45,43.26) v10(24.11,50.55) v10(24.34,43.26) v10(24.85,50.55) v10(25.11,43.26) v10(25.99,63.71) v10(90.26,67.14) v10(91.02,67.14) v10(91.78,67.14) v10(104.07,23.4) v10(104.41,66.5) v10(104.79,65.84) v10(104.81,23.4) v10(105.06,63.53) v10(105.06,62.46) v10(105.06,61.42) v10(105.12,13.95) v10(105.06,12.45) v10(105.24,66.5) v10(105.55,23.4) v10(105.47,13.19) v10(105.62,65.84) v10(105.88,13.95) v10(105.85,12.53) v10(106.02,66.5) v10(106,63.53) v10(106,62.44) v10(106,61.42) v10(106.21,13.19) v10(106.41,65.84) v10(106.64,13.95) v10(106.82,66.51) v10(106.94,13.19) v10(107.21,65.85) v10(111.44,67.47) v10(112.2,67.47) v10(113.65,67.49) v10(114.46,67.47) v10(118.53,30.92) v10(118.53,30.15) v10(119.26,30.92) v10(119.26,30.15) v10(120,30.92) v10(120,30.15) v10(120.74,30.92) v10(120.69,6.23) v10(121.45,6.23) v10(122.21,6.23) v10(122.97,6.23) v10(123.43,17.23) v10(123.73,6.23) v10(124.17,17.23) v10(124.17,16.46) v10(124.9,17.23) v10(124.9,16.46) v10(124.9,15.73) v10(124.9,14.99) v10(124.9,14.25) v10(125.69,15.73) v10(125.69,14.99) v10(125.69,14.25) v10(132.39,22.41) v10(133.08,23.91) v10(133.06,23.14) v10(133.87,24.13) v10(137.22,33.05) v10(137.6,33.68) v10(137.98,33.05) v10(138.36,33.68) v10(138.74,33.05) v10(139.13,33.68) v10(139.51,33.05) v10(139.91,33.68) v10(140.29,33.05) v10(140.68,33.68) v10(141.06,33.05) v10(145.5,66.12) v10(146.97,28.16) v10(146.97,27.41) v10(153.38,63.71) v10(156.35,27.93) v10(156.36,27.18) v10(157.95,64.09) v10(158.35,34.12) v10(158.35,33.35) v10(159.09,34.12) v10(159.09,33.35) v10(159.83,34.12) v10(159.83,33.35) v10(160.56,34.12) v10(160.56,33.35) v10(162.77,64.09) v10(163.99,31.44) v10(164.81,31.45) v10(165.19,61.24) v10(170.46,6.98) v10(171.69,62.08) v10(171.85,6.93) v10(172.87,56.08) v10(172.87,55.33) v10(172.85,51.64) v10(173.03,6.98) v10(175.14,66.63) v10(175.17,65.89) v10(175.22,49.03) v10(176.81,61.55) v10(177.07,49.36) v10(177.57,61.55) v10(177.59,60.75) v10(178.31,61.57) v10(178.35,60.75) v10(180.83,61.93) v10(181.85,62.97) v10(181.85,61.93) v10(183.78,10.86) v10(183.79,9.79) v10(188.89,9.63) v10(188.91,8.56) v10(189.44,59.52) v10(190.18,58.53) v10(190.87,63.86) v10(191.58,66.76) v10(192.11,62.95) v10(193.76,66.76) v10(193.76,64.47) v10(193.76,62.95) v10(193.76,60.53) v10(194.27,33.35) v10(194.5,40.92) v10(197.49,42.3) v10(197.83,29.29) v10(207.6,67.9) v10(218.02,20.15) v10(218.02,18.88)
