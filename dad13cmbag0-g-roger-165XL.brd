# Allegro board dad13cmbag0-g-roger-165XL.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_A_BS2: length 127.8
  TOP w0.089: v9(34.35,13.57) 34.27,13.64 v7(32.39,13.64) 32.27,13.64 31.26,14.65 31.26,14.88 30.69,15.45 30.69,15.83 30.44,16.08 30.07,16.08 R413.2
  IN1 w0.076: v5(23.5,14.36) 23.28,14.13 21.27,14.13 21.14,14.25 21.14,14.55 21.3,14.7 22.37,14.7 22.69,15.02 23.78,15.02 24.04,14.76 24.83,14.76 25.23,14.36 26.83,14.36 27.29,13.9 28.48,13.9 28.79,14.2 34.22,14.2 34.35,14.08 v9(34.35,13.57) 34.63,13.57 34.71,13.64 34.71,14.15 34.76,14.2 34.99,14.2 35.04,14.15 35.04,13.72 35.09,13.67 35.29,13.67 35.34,13.72 35.34,14.05 35.42,14.13 35.58,14.13 35.7,14.01 35.7,13.9 35.9,13.7 41.59,13.7 41.89,14 41.89,14.2 41.97,14.28 42.31,14.28 42.39,14.2 42.39,13.95 42.46,13.87 42.62,13.87 42.69,13.95 42.69,14.2 42.77,14.28 42.92,14.28 43,14.2 43,13.95 43.07,13.87 43.22,13.87 43.3,13.95 43.3,14.2 43.38,14.28 43.53,14.28 43.61,14.2 43.61,13.95 43.68,13.87 43.83,13.87 43.91,13.95 43.91,14.2 43.99,14.28 44.18,14.28 44.26,14.2 44.26,13.9 44.31,13.84 44.53,13.84 44.61,13.92 44.61,14.2 44.69,14.28 44.97,14.28 45.6,14.91 46.24,14.91 46.34,14.81 46.34,14.61 46.09,14.36 v5(45.86,14.36)
  IN2 w0.165: v5(55.05,37.57) 54.98,37.57 53.78,36.38 53.78,35.18 53.17,34.57 46.01,34.57 43.44,32 43.44,31.11 43.27,30.94 43.01,30.94 42.57,31.38 42.31,31.38 42.13,31.2 42.13,30.94 42.59,30.48 42.59,30.21 42.4,30.02 42.13,30.02 40.78,31.37 40.53,31.37 40.34,31.18 40.34,30.9 41.68,29.56 41.68,29.3 41.49,29.11 41.23,29.11 39.88,30.47 39.63,30.47 39.44,30.28 39.44,30.01 40.79,28.67 40.79,28.41 40.61,28.23 40.36,28.23 39,29.59 38.75,29.59 38.57,29.41 38.57,29.16 39.93,27.8 39.93,27.55 39.76,27.38 39.52,27.38 38.14,28.76 37.92,28.76 33.53,24.36 33.53,20.3 33.72,20.11 33.72,14.2 v9(34.35,13.57)
  IN4 w0.076: v2(30.39,14.17) 29.58,14.17 28.84,14.91 24.67,14.91 24.11,14.36 v5(23.5,14.36) 21.73,14.36 21.27,13.9 19.8,13.9 19.72,13.97 19.72,14.15 19.67,14.2 19.54,14.2 19.49,14.15 19.49,13.77 19.39,13.67 18.4,13.67 18.35,13.72 18.35,13.85 18.78,14.28 19.1,14.28 v2(19.21,14.17) ; v2(41.56,14.17) 41.46,14.28 41.13,14.28 40.7,13.85 40.7,13.72 40.75,13.67 41.74,13.67 41.84,13.77 41.84,14.15 41.89,14.2 42.02,14.2 42.07,14.15 42.07,13.97 42.15,13.9 43.62,13.9 44.08,14.36 v5(45.86,14.36) 46.47,14.36 47.03,14.91 51.19,14.91 51.93,14.17 v2(52.74,14.17)
  IN4 w0.165: v5(55.05,37.57) 54.32,37.57 53.88,38 53.88,38.47 v2(53.27,39.09)
M_A_CAS#: length 125.2
  TOP w0.089: v9(36.28,16.95) 36.28,16.92 35.95,16.59 34.63,16.59 33.72,17.51 33.72,18.53 R432.2
  IN1 w0.076: v5(24.34,17.51) 24.64,17.8 28.64,17.8 28.72,17.72 28.72,17.51 28.79,17.43 28.95,17.43 29.02,17.51 29.02,17.72 29.1,17.8 29.25,17.8 29.33,17.72 29.33,17.51 29.4,17.43 29.56,17.43 29.63,17.51 29.63,17.72 29.71,17.8 29.86,17.8 29.94,17.72 29.94,17.51 30.01,17.43 30.17,17.43 30.24,17.51 30.24,17.72 30.32,17.8 30.47,17.8 30.55,17.72 30.55,17.51 30.62,17.43 30.78,17.43 30.85,17.51 30.85,17.72 30.93,17.8 31.08,17.8 31.16,17.72 31.16,17.51 31.23,17.43 31.39,17.43 31.46,17.51 31.46,17.72 31.54,17.8 31.69,17.8 31.77,17.72 31.77,17.28 31.82,17.23 35.57,17.23 35.85,16.95 v9(36.28,16.95) 36.41,17.07 36.81,17.07 37.17,17.43 37.37,17.43 37.44,17.35 37.44,17.2 37.52,17.12 37.67,17.12 37.75,17.2 37.75,17.35 37.83,17.43 37.98,17.43 38.05,17.35 38.05,17.2 38.13,17.12 38.28,17.12 38.36,17.2 38.36,17.35 38.44,17.43 38.59,17.43 38.66,17.35 38.66,17.2 38.74,17.12 38.89,17.12 38.97,17.2 38.97,17.35 39.04,17.43 39.2,17.43 39.27,17.35 39.27,17.2 39.35,17.12 39.5,17.12 39.58,17.2 39.58,17.35 39.65,17.43 39.81,17.43 39.88,17.35 39.88,17.2 39.96,17.12 40.11,17.12 40.19,17.2 40.19,17.35 40.26,17.43 40.42,17.43 40.49,17.35 40.49,17.2 40.57,17.12 40.72,17.12 40.8,17.2 40.8,17.35 40.87,17.43 41.03,17.43 41.1,17.35 41.1,17.2 41.18,17.12 41.33,17.12 41.41,17.2 41.41,17.35 41.48,17.43 41.64,17.43 41.71,17.35 41.71,17.2 41.79,17.12 41.94,17.12 42.02,17.2 42.02,17.35 42.09,17.43 42.25,17.43 42.32,17.35 42.32,17.2 42.4,17.12 42.55,17.12 42.63,17.2 42.63,17.35 42.7,17.43 42.96,17.43 43.05,17.34 44.78,17.34 45.04,17.61 45.45,17.61 45.55,17.51 45.55,17.28 45.63,17.2 45.78,17.2 45.86,17.28 45.86,17.48 45.96,17.58 46.09,17.58 46.19,17.48 46.19,17.25 46.26,17.17 46.59,17.17 46.7,17.28 v5(46.7,17.51)
  IN2 w0.165: v9(36.28,16.95) 36.99,16.95 38.64,18.6 39.28,18.6 39.52,18.84 39.52,20.9 39.69,21.07 39.99,21.07 40.12,20.94 40.12,18.75 40.24,18.62 40.55,18.62 40.68,18.75 40.68,22.06 40.8,22.18 41.1,22.18 41.22,22.06 41.22,19.71 41.35,19.59 41.67,19.59 41.79,19.71 41.79,20.94 41.92,21.07 42.22,21.07 42.35,20.94 42.35,19.74 42.48,19.61 42.81,19.61 42.94,19.74 42.94,20.94 43.06,21.07 43.39,21.07 43.52,20.94 43.52,19.77 43.65,19.64 43.95,19.64 44.08,19.77 44.08,20.94 44.21,21.07 44.51,21.07 44.64,20.94 44.64,19.77 44.76,19.64 45.07,19.64 45.2,19.77 45.2,20.94 45.32,21.07 45.63,21.07 45.76,20.94 45.76,19.96 45.88,19.83 46.19,19.83 46.31,19.96 46.31,20.94 46.44,21.07 47.42,21.07 48.86,22.51 51.05,22.51 55.31,26.77 55.31,28.25 59.62,32.57 59.62,39.78 58.82,40.58 v5(58.14,40.58)
  IN4 w0.076: v2(41.56,15.77) 41.56,15.83 42.2,16.46 42.2,16.59 41.82,16.97 41.82,17.12 41.95,17.25 42.53,17.25 42.62,17.34 44.73,17.34 44.94,17.56 46.64,17.56 v5(46.7,17.51) 46.87,17.68 47.99,17.68 49.24,16.44 52.07,16.44 v2(52.74,15.77) ; v2(30.39,15.77) 30.39,16.11 30.06,16.44 26.88,16.44 25.64,17.68 24.52,17.68 v5(24.34,17.51) 24.29,17.56 22.59,17.56 22.37,17.34 20.55,17.34 20.18,16.97 19.97,16.97 19.69,17.25 19.59,17.25 19.47,17.12 19.47,16.97 19.85,16.59 19.85,16.46 19.21,15.83 v2(19.21,15.77)
  IN4 w0.165: v5(58.14,40.58) 58.04,40.69 v2(58.04,41.04)
M_A_CKE0: length 105.9
  TOP w0.089: R433.2 30.03,18.5 v7(30.69,17.84) 30.69,16.92 v9(30.36,16.59)
  IN1 w0.076: v5(42.91,16.21) 42.68,16.44 30.54,16.44 30.39,16.59 v9(30.36,16.59) 29.91,16.59 29.73,16.77 25.51,16.77 25.23,17.05 24.93,17.05 24.72,16.84 24.57,16.84 24.5,16.77 24.5,16.57 24.42,16.49 24.19,16.49 24.11,16.57 24.11,16.64 24.04,16.72 23.81,16.72 23.73,16.64 23.73,16.57 23.66,16.49 23.43,16.49 23.35,16.57 23.35,16.64 23.28,16.72 23.05,16.72 22.97,16.64 22.97,16.5 22.91,16.44 22.65,16.44 22.59,16.5 22.59,16.64 22.51,16.72 22.29,16.72 22.21,16.64 22.21,16.39 22.03,16.21 v5(20.56,16.21)
  IN2 w0.165: v5(51.37,40.75) 51.37,40.65 50.64,39.92 50.32,39.92 49.69,39.29 49.23,39.29 49.04,39.11 48.27,39.11 48.09,39.29 48.09,40.17 47.93,40.34 47,40.34 46.87,40.21 46.87,39.91 46.75,39.78 46.39,39.78 46.26,39.91 46.26,40.21 46.14,40.34 45.81,40.34 45.68,40.21 45.68,39.91 45.55,39.78 45.22,39.78 45.09,39.91 45.09,40.72 44.97,40.85 44.64,40.85 44.51,40.72 44.51,39.91 44.38,39.78 44.03,39.78 43.9,39.91 43.9,40.72 43.77,40.85 43.44,40.85 43.32,40.72 43.32,39.83 43.19,39.7 42.89,39.7 42.76,39.83 42.76,40.21 42.63,40.34 42.38,40.34 41.49,39.45 40.85,39.45 40.6,39.7 38.57,39.7 27.9,29.03 27.9,27.9 26.63,26.63 26.63,17.35 27.39,16.59 v9(30.36,16.59)
  IN4 w0.076: v2(14.41,15.77) 14.95,15.24 19.46,15.24 20.43,16.21 v5(20.56,16.21) 20.63,16.29 21.88,16.29 22.39,16.79 22.72,16.79 22.82,16.9 24.75,16.9 v2(24.95,17.1) ; v2(36.76,15.77) 37.3,15.24 41.76,15.24 42.73,16.21 v5(42.91,16.21) 42.99,16.29 44.23,16.29 44.74,16.79 45.07,16.79 45.17,16.9 47.1,16.9 v2(47.3,17.1)
  IN4 w0.165: v2(51.74,41.04) 51.66,41.04 v5(51.37,40.75)
  BOTTOM w0.076: U19.K9 25.26,15.77 24.9,16.13 24.9,17.05 v2(24.95,17.1) ; U21.K9 47.62,15.77 47.25,16.13 47.25,17.05 v2(47.3,17.1)
M_A_CKE1: length 105.7
  TOP w0.076: v9(30.31,17) 30.17,17 R434.2
  IN1 w0.076: v5(20.56,16.79) 20.56,17 20.61,17.05 20.83,17.05 20.91,16.97 20.91,16.69 21.07,16.54 21.73,16.54 21.84,16.65 21.84,17.42 21.93,17.51 22.5,17.51 22.57,17.44 22.57,17.07 22.64,17 22.79,17 22.87,17.07 22.87,17.47 22.96,17.56 23.09,17.56 23.17,17.47 23.17,17.07 23.25,17 23.4,17 23.48,17.07 23.48,17.77 23.57,17.86 23.7,17.86 23.78,17.77 23.78,17.07 23.86,17 24.19,17 24.27,17.07 24.42,17.07 24.67,17.33 25.46,17.33 25.7,17.09 30.22,17.09 v9(30.31,17) 30.72,17 30.85,16.87 30.85,16.79 30.93,16.72 31.08,16.72 31.15,16.79 31.15,16.87 31.23,16.95 31.38,16.95 31.46,16.87 31.46,16.79 31.54,16.72 31.69,16.72 31.76,16.79 31.76,16.87 31.84,16.95 31.99,16.95 32.07,16.87 32.07,16.79 32.14,16.72 32.3,16.72 32.37,16.79 32.37,16.87 32.45,16.95 32.67,16.95 32.75,16.87 32.75,16.82 32.85,16.72 33.08,16.72 33.16,16.79 33.16,16.84 33.26,16.95 35.49,16.95 35.76,16.68 36.67,16.68 36.79,16.79 v5(42.91,16.79)
  IN2 w0.165: v9(30.31,17) 28.25,17 27.01,18.24 27.01,26.49 29.87,29.35 29.87,30.48 37.88,38.49 37.88,38.49 39.71,38.49 39.84,38.61 39.84,39.2 39.96,39.32 40.35,39.32 40.47,39.2 40.47,38.61 40.6,38.49 42,38.49 42.12,38.61 42.12,39.2 42.25,39.32 42.63,39.32 42.76,39.2 42.76,38.61 42.89,38.49 43.27,38.49 43.39,38.61 43.39,39.29 43.52,39.41 43.9,39.41 44.03,39.29 44.03,38.61 44.16,38.49 44.51,38.49 44.64,38.61 44.64,39.29 44.77,39.41 47.37,39.41 48.04,38.74 49.24,38.74 49.5,39.01 50.6,39.01 51.09,39.5 v5(51.32,39.5)
  IN4 w0.076: v2(47.94,16.82) 48.09,16.82 48.17,16.9 48.17,17.12 47.99,17.3 47.89,17.3 47.84,17.25 47.84,17.12 47.76,17.05 47.66,17.05 47.58,17.12 47.58,17.25 47.43,17.4 47.15,17.4 46.9,17.15 46.49,17.15 46.31,17.33 45.17,17.33 44.92,17.07 44.61,17.07 44.08,16.54 43.16,16.54 v5(42.91,16.79) 42.91,16.72 41.69,15.5 37.84,15.5 v2(36.76,16.57) ; v2(25.59,16.82) 25.74,16.82 25.82,16.9 25.82,17.12 25.64,17.3 25.54,17.3 25.49,17.25 25.49,17.12 25.41,17.05 25.31,17.05 25.23,17.12 25.23,17.25 25.08,17.4 24.8,17.4 24.55,17.15 24.14,17.15 23.96,17.33 22.82,17.33 22.57,17.07 22.26,17.07 21.73,16.54 20.81,16.54 v5(20.56,16.79) 20.56,16.72 19.34,15.5 15.49,15.5 v2(14.41,16.57)
  IN4 w0.165: v5(51.32,39.5) 51.55,39.74 v2(51.69,39.74)
  BOTTOM w0.076: U19.J9 v2(25.59,16.82) ; U21.J9 v2(47.94,16.82)
M_A_CLKN0: length 119.6
  TOP w0.076: v9(34.18,18.47) 34.33,18.62 34.71,18.62 34.8,18.53 R228.1
  IN1 w0.102: v5(44.31,17.98) 43.62,18.67 43.21,18.67 42.99,18.89 42.99,19.3 42.89,19.4 42.59,19.4 42.48,19.3 42.48,18.89 42.26,18.67 41.79,18.67 41.57,18.89 41.57,19.3 41.47,19.4 41.16,19.4 41.06,19.3 41.06,18.89 40.84,18.67 40.37,18.67 40.15,18.89 40.15,19.3 40.05,19.4 39.74,19.4 39.64,19.3 39.64,18.89 39.42,18.67 38.95,18.67 38.72,18.89 38.72,19.3 38.62,19.4 38.32,19.4 38.22,19.3 38.22,18.89 38,18.67 37.52,18.67 37.3,18.89 37.3,19.27 37.2,19.37 36.9,19.37 36.79,19.27 36.79,18.89 36.57,18.67 36.1,18.67 35.88,18.89 35.88,19.3 35.8,19.37 35.48,19.37 34.87,18.77 34.48,18.77 v9(34.18,18.47) 33.87,18.77 33.47,18.77 33.03,19.21 32.73,19.21 32.63,19.11 32.63,18.89 32.41,18.67 31.93,18.67 31.71,18.89 31.71,19.18 31.61,19.28 31.31,19.28 31.21,19.18 31.21,18.89 30.98,18.67 30.51,18.67 30.29,18.89 30.29,19.11 30.19,19.21 29.88,19.21 29.78,19.11 29.78,18.89 29.56,18.67 29.09,18.67 28.87,18.89 28.87,19.11 28.77,19.21 28.46,19.21 28.36,19.11 28.36,18.89 28.14,18.67 27.67,18.67 27.45,18.89 27.45,19.11 27.34,19.21 27.04,19.21 26.94,19.11 26.94,18.89 26.72,18.67 26.24,18.67 26.02,18.89 26.02,19.07 25.87,19.22 25.6,19.22 25.05,18.67 23.38,18.67 22.93,18.22 22.2,18.22 v5(21.96,17.98)
  IN2 w0.089: v5(55.2,40.7) 55.36,40.54 55.48,40.54 55.79,40.24 55.79,37.52 55.06,36.79 55.06,36.7
  IN2 w0.203: v9(34.18,18.47) 34.41,18.7 34.71,18.7 35.04,19.03 35.04,21.66 35.5,22.12 35.5,22.66 34.46,23.7 34.46,23.99 34.74,24.27 35.03,24.27 36.23,23.08 36.77,23.08 37.24,23.54 37.24,24.08 36.02,25.3 36.02,25.59 36.3,25.88 36.59,25.88 37.82,24.64 38.36,24.64 38.83,25.11 38.83,25.65 37.6,26.88 37.6,27.17 37.89,27.46 38.17,27.46 39.29,26.34 39.99,26.34 44.33,30.69 44.33,31.63 46.38,33.67 53.79,33.67 54.7,34.58 54.7,36.34 55.06,36.7
  IN4 w0.089: v2(55.54,41.04) v5(55.2,40.7)
  IN4 w0.102: v2(39.44,16.95) 39.44,17.18 39.53,17.28 40.04,17.28 40.27,17.51 40.27,18.82 40.73,19.28 41.12,19.28 41.94,18.47 43.82,18.47 v5(44.31,17.98) 44.31,18.14 44.4,18.24 44.75,18.24 44.92,18.41 48.9,18.41 49.98,17.33 50.35,17.33 v2(50.48,17.2) ; v2(17.08,16.95) 17.08,17.18 17.18,17.28 17.82,17.28 18.05,17.51 18.05,18.82 18.51,19.28 20.65,19.28 v5(21.96,17.98) 21.96,18.14 22.05,18.24 22.4,18.24 22.57,18.41 26.55,18.41 27.63,17.33 28,17.33 v2(28.13,17.2)
  BOTTOM w0.102: v2(17.08,16.95) 17.08,17.12 17,17.2 16.86,17.2 16.71,17.05 16.71,16.47 16.32,16.08 16.22,16.08 16.01,15.87 U18.K7 ; U21.K7 49.54,15.85 49.79,16.11 49.98,16.11 50.17,16.3 50.17,17.09 50.34,17.25 50.43,17.25 v2(50.48,17.2) ; U19.K7 27.19,15.85 27.44,16.11 27.63,16.11 27.82,16.3 27.82,17.09 27.98,17.25 28.08,17.25 v2(28.13,17.2) ; U20.K7 38.36,15.87 38.57,16.08 38.68,16.08 39.06,16.47 39.06,17.05 39.21,17.2 39.35,17.2 39.44,17.12 v2(39.44,16.95)
M_A_CLKP0: length 119.1
  TOP w0.076: R225.1 34.49,18.93 34.3,18.93 34.17,19.05 v9(34.17,19.28)
  IN1 w0.102: v5(21.96,18.7) 22.23,18.42 22.84,18.42 23.3,18.87 24.97,18.87 25.52,19.42 25.96,19.42 26.23,19.15 26.23,18.97 26.33,18.87 26.63,18.87 26.74,18.97 26.74,19.19 26.96,19.41 27.43,19.41 27.65,19.19 27.65,18.97 27.75,18.87 28.06,18.87 28.16,18.97 28.16,19.19 28.38,19.41 28.85,19.41 29.07,19.19 29.07,18.97 29.17,18.87 29.48,18.87 29.58,18.97 29.58,19.19 29.8,19.41 30.27,19.41 30.49,19.19 30.49,18.97 30.6,18.87 30.9,18.87 31,18.97 31,19.27 31.22,19.49 31.7,19.49 31.92,19.27 31.92,18.97 32.02,18.87 32.32,18.87 32.42,18.97 32.42,19.19 32.65,19.41 33.12,19.41 33.56,18.97 33.86,18.97 v9(34.17,19.28) 34.48,18.97 34.79,18.97 35.39,19.58 35.89,19.58 36.08,19.38 36.08,18.97 36.18,18.87 36.49,18.87 36.59,18.97 36.59,19.35 36.81,19.58 37.29,19.58 37.51,19.35 37.51,18.97 37.61,18.87 37.91,18.87 38.01,18.97 38.01,19.38 38.23,19.6 38.71,19.6 38.93,19.38 38.93,18.97 39.03,18.87 39.33,18.87 39.44,18.97 39.44,19.38 39.66,19.6 40.13,19.6 40.35,19.38 40.35,18.97 40.45,18.87 40.76,18.87 40.86,18.97 40.86,19.38 41.08,19.6 41.55,19.6 41.77,19.38 41.77,18.97 41.87,18.87 42.18,18.87 42.28,18.97 42.28,19.38 42.5,19.6 42.97,19.6 43.2,19.38 43.2,18.97 43.3,18.87 43.7,18.87 44.05,18.52 44.26,18.52 44.31,18.57 v5(44.31,18.7)
  IN2 w0.089: v5(55.2,40.03) 55.2,40.26 55.31,40.36 55.41,40.36 55.61,40.16 55.61,37.59 54.93,36.92 54.84,36.92
  IN2 w0.203: 54.84,36.92 54.39,36.47 54.39,34.7 53.67,33.98 46.25,33.98 44.03,31.75 44.03,30.81 39.86,26.65 39.41,26.65 38.3,27.76 37.76,27.76 37.29,27.3 37.29,26.76 38.53,25.52 38.53,25.24 38.24,24.95 37.95,24.95 36.72,26.18 36.18,26.18 35.71,25.72 35.71,25.17 36.93,23.95 36.93,23.67 36.64,23.38 36.36,23.38 35.16,24.58 34.62,24.58 34.15,24.11 34.15,23.57 35.19,22.53 35.19,22.24 34.74,21.79 34.74,19.16 34.58,19 34.33,19 34.17,19.16 v9(34.17,19.28)
  IN4 w0.089: v2(55.59,40.39) 55.48,40.39 55.2,40.11 v5(55.2,40.03)
  IN4 w0.102: v2(39.44,17.75) 39.44,17.6 39.56,17.48 39.96,17.48 40.07,17.59 40.07,18.91 40.65,19.49 41.21,19.49 42.02,18.67 43.9,18.67 44.05,18.52 44.13,18.52 v5(44.31,18.7) 44.31,18.6 44.47,18.44 44.67,18.44 44.84,18.61 48.98,18.61 50.06,17.53 50.43,17.53 v2(50.51,17.61) ; v2(28.15,17.61) 28.08,17.53 27.71,17.53 26.63,18.61 22.49,18.61 22.32,18.44 22.11,18.44 21.96,18.6 v5(21.96,18.7) 21.78,18.52 21.7,18.52 20.74,19.49 18.42,19.49 17.84,18.91 17.84,17.59 17.73,17.48 17.21,17.48 17.08,17.6 v2(17.08,17.75)
  BOTTOM w0.102: U21.J7 49.54,16.48 49.71,16.31 49.9,16.31 49.97,16.39 49.97,17.17 50.31,17.52 50.42,17.52 v2(50.51,17.61) ; v2(28.15,17.61) 28.06,17.52 27.96,17.52 27.62,17.17 27.62,16.39 27.54,16.31 27.36,16.31 27.19,16.48 U19.J7 ; U18.J7 16.01,16.39 16.11,16.29 16.24,16.29 16.51,16.55 16.51,17.14 17.08,17.71 17.08,17.75 v2(17.08,17.75) ; U20.J7 38.36,16.39 38.47,16.29 38.59,16.29 38.86,16.55 38.86,17.14 39.43,17.71 39.43,17.75 v2(39.44,17.75)
M_A_CS#0: length 109.2
  TOP w0.089: R239.2 33.78,15.88 v7(33.97,15.88) 35.82,15.88 v9(35.93,15.78)
  IN1 w0.076: v5(47.41,16.67) 47.03,16.29 45.27,16.29 44.82,15.83 43.9,15.83 43.74,15.66 42.52,15.66 42.35,15.83 35.98,15.83 v9(35.93,15.78) 34.27,15.78 34.17,15.68 26.04,15.68 v5(25.05,16.67)
  IN2 w0.165: v9(35.93,15.78) 36.36,16.21 37.06,16.21 37.83,16.97 38.72,16.97 38.87,17.12 38.87,17.84 39,17.96 39.33,17.96 39.46,17.84 39.46,17.12 39.58,17 39.94,17 40.07,17.12 40.07,17.92 40.19,18.05 40.52,18.05 40.65,17.92 40.65,17.15 40.78,17.02 41.12,17.02 41.25,17.15 41.25,18.89 41.37,19.02 41.72,19.02 41.84,18.89 41.84,17.1 41.97,16.97 42.33,16.97 42.45,17.1 42.45,18.24 42.58,18.37 42.91,18.37 43.04,18.24 43.04,17.58 43.16,17.45 44.61,17.45 44.73,17.58 44.73,18.56 44.86,18.68 45.85,18.68 46.89,19.72 46.89,20.31 47.08,20.5 47.66,20.5 49.1,21.94 51.28,21.94 55.88,26.53 55.88,28.02 60.2,32.33 60.2,40.53 59.42,41.3 58.41,41.3 v5(57.92,41.79)
  IN4 w0.076: v2(20.01,14.97) 19.79,14.97 19.72,15.04 19.72,15.14 19.9,15.32 20.43,15.32 20.53,15.42 20.53,15.5 20.38,15.65 20.38,15.75 20.48,15.85 20.61,15.85 20.71,15.75 20.84,15.75 21.12,16.03 22.23,16.03 22.49,16.29 22.49,16.49 22.57,16.57 22.92,16.57 22.97,16.62 25,16.62 v5(25.05,16.67) 25.36,16.67 25.51,16.51 26.5,16.51 26.83,16.18 29.42,16.18 30.1,15.51 30.65,15.51 30.82,15.68 31.1,15.68 31.19,15.59 v2(31.19,14.97) ; v2(42.36,14.97) 42.14,14.97 42.07,15.04 42.07,15.14 42.25,15.32 42.78,15.32 42.89,15.42 42.89,15.5 42.73,15.65 42.73,15.75 42.83,15.85 42.96,15.85 43.06,15.75 43.19,15.75 43.47,16.03 44.59,16.03 44.84,16.29 44.84,16.49 44.92,16.57 45.27,16.57 45.32,16.62 47.36,16.62 v5(47.41,16.67) 47.71,16.67 47.86,16.51 48.85,16.51 49.18,16.18 51.78,16.18 52.45,15.51 53.44,15.51 53.54,15.41 v2(53.54,14.97)
  IN4 w0.165: v2(58.29,42.85) 58.29,42.15 v5(57.92,41.79)
M_A_CS#1: length 106.6
  TOP w0.089: v9(38.24,16.11) 38.47,16.35 R236.2
  IN1 w0.076: v5(48.83,16.03) 48.6,16.03 48.5,16.13 48.5,16.39 48.42,16.46 48.27,16.46 48.19,16.39 48.19,16.13 48.09,16.03 47.91,16.03 47.81,16.13 47.81,16.87 47.66,17.02 47.23,17.02 46.9,16.69 44.66,16.69 44.56,16.59 44.56,16.18 44.49,16.11 44.23,16.11 44.13,16.21 44.13,16.44 44.05,16.51 43.82,16.51 43.75,16.44 43.75,16.18 43.67,16.11 43.52,16.11 43.28,15.87 42.67,15.87 42.43,16.11 v9(38.24,16.11) 33.82,16.11 33.74,16.03 29.72,16.03 29.64,16.11 29.64,16.26 29.56,16.34 29.41,16.34 29.33,16.26 29.33,16.11 29.26,16.03 29.11,16.03 29.03,16.11 29.03,16.26 28.95,16.34 28.8,16.34 28.72,16.26 28.72,16.11 28.65,16.03 28.5,16.03 28.42,16.11 28.42,16.26 28.34,16.34 28.19,16.34 28.12,16.26 28.12,16.11 28.04,16.03 27.89,16.03 27.81,16.11 27.81,16.26 27.73,16.34 27.58,16.34 27.51,16.26 27.51,16.11 27.43,16.03 27.28,16.03 27.2,16.11 27.2,16.26 27.12,16.34 26.97,16.34 26.9,16.26 26.9,16.11 26.82,16.03 v5(26.48,16.03)
  IN2 w0.165: v9(38.24,16.11) 39.33,16.11 39.79,16.57 40.09,16.57 40.22,16.44 40.22,15.96 40.35,15.83 40.65,15.83 40.78,15.96 40.78,16.44 40.9,16.57 41.21,16.57 41.34,16.44 41.34,15.96 41.46,15.83 41.77,15.83 41.89,15.96 41.89,16.44 42.02,16.57 42.33,16.57 42.45,16.44 42.45,14.89 42.58,14.76 42.89,14.76 43.01,14.89 43.01,15.68 43.14,15.8 43.44,15.8 43.57,15.68 43.57,14.89 43.7,14.76 44,14.76 44.13,14.89 44.13,16.79 44.26,16.92 45,16.92 45.13,17.05 45.13,18.19 45.25,18.32 45.55,18.32 45.68,18.19 45.68,16.97 45.81,16.84 46.11,16.84 46.23,16.97 46.23,18.55 49.25,21.57 51.44,21.57 60.56,30.7 60.56,40.7 59.5,41.76 v5(58.58,41.76)
  IN4 w0.076: v2(20.81,14.97) 20.81,15.27 21.32,15.78 22.67,15.78 23.12,16.24 26.27,16.24 v5(26.48,16.03) 26.58,15.93 29.19,15.93 29.89,15.24 30.52,15.24 31.1,14.66 31.76,14.66 31.99,14.89 v2(31.99,14.97) ; v2(43.16,14.97) 43.16,15.27 43.67,15.78 45.02,15.78 45.48,16.24 48.63,16.24 v5(48.83,16.03) 48.93,15.93 51.55,15.93 52.24,15.24 52.87,15.24 53.45,14.66 54.11,14.66 54.34,14.89 v2(54.34,14.97)
  IN4 w0.165: v5(58.58,41.76) 59.02,42.2 v2(59.19,42.2)
M_A_DQ0: length 41.6
  IN3 w0.152: v2(39.39,46.44) 37.37,44.42 37.37,39.02 29.21,30.86 28.38,30.86 26.86,29.34 26.86,28.22 26.38,27.74 25.26,27.74 22.84,25.32 22.84,24.18 22.2,23.53 21.05,23.53 17.72,20.2 17.72,19.16 16.76,18.2 16.76,17.15 16.58,16.97 16.19,16.97 16.01,17.15 v2(16.01,17.37)
M_A_DQ1: length 42.1
  IN3 w0.152: v2(40.04,46.44) 39.74,46.73 39.24,46.73 37.02,44.51 37.02,39.25 31.54,33.77 30.96,33.77 29.8,32.62 29.8,32.03 29.01,31.24 28.22,31.24 26.48,29.49 26.48,28.37 26.22,28.12 25.1,28.12 22.46,25.48 22.46,24.35 22.02,23.91 20.89,23.91 17.34,20.36 17.34,19.32 16.25,18.24 16.07,18.24 15.94,18.37 15.94,18.9 v2(16.01,18.97)
M_A_DQ2: length 40.4
  IN3 w0.089: 38.29,38.31 38.29,44.1 39.27,45.09 v2(39.39,45.09)
  IN3 w0.152: 38.29,38.31 37.3,37.32 37.3,36.22 36.89,35.82 36.2,35.82 29.19,28.81 28.94,28.81 28.57,29.18 28.39,29.18 28.05,28.84 28.05,28.66 28.43,28.27 28.43,28.05 24.39,24.01 24.39,23.19 24.19,22.99 23.38,22.99 23.12,22.74 23.12,22.53 23.72,21.93 23.72,21.75 23.5,21.53 23.29,21.53 22.48,22.34 22.3,22.34 22.07,22.1 22.07,21.92 22.79,21.2 22.79,21.01 22.67,20.88 20.09,20.88 19.21,20 v2(19.21,19.77)
M_A_DQ3: length 42
  IN3 w0.089: v2(40.04,45.08) 39.78,44.82 39.34,44.82 38.59,44.07 38.59,39.32
  IN3 w0.152: v2(19.21,17.37) 19.62,17.78 19.62,19.87 20.25,20.5 23.01,20.5 23.49,20.98 24.49,20.98 24.77,21.26 24.77,23.7 34.73,33.66 34.95,33.66 35.3,33.3 35.52,33.3 35.73,33.52 35.73,33.73 35.38,34.09 35.38,34.3 35.59,34.52 35.81,34.52 36.16,34.16 36.38,34.16 36.6,34.38 36.6,34.6 36.24,34.95 36.24,35.17 36.51,35.44 37.6,35.44 37.78,35.62 37.78,37.37 38.59,38.18 38.59,39.32
M_A_DQ4: length 42.1
  IN3 w0.152: v2(40.69,46.44) 40.15,46.97 39.13,46.97 36.71,44.56 36.71,39.5 33.21,36 32.42,36 22.08,25.66 22.08,24.51 21.86,24.29 20.72,24.29 16.67,20.25 16.67,19.97 16.96,19.68 16.96,19.48 16.71,19.23 16.49,19.23 16.14,19.59 15.97,19.59 15.35,18.97 v2(15.21,18.97)
M_A_DQ5: length 43.3
  IN3 w0.152: v2(41.34,46.44) 40.56,47.21 39.01,47.21 36.41,44.61 36.41,39.76 33.03,36.38 32.22,36.38 15.28,19.44 15.02,19.44 14.77,19.18 14.77,17.82 v2(15.21,17.37)
M_A_DQ6: length 41.6
  IN3 w0.089: 38.92,39.17 38.9,39.2 38.9,40.49 38.82,40.57 38.82,43.33 38.83,43.33 38.83,44.03 39.45,44.65 40.46,44.65 40.52,44.71 40.52,45.14 40.57,45.19 v2(40.69,45.19)
  IN3 w0.152: v2(20.01,18.97) 20.01,19.68 20.46,20.12 23.17,20.12 23.52,20.48 25.38,20.48 25.54,20.63 25.54,20.96 25.16,21.34 25.16,21.82 25.54,22.2 25.54,22.69 25.16,23.07 25.16,23.54 25.34,23.73 25.62,23.73 25.97,23.37 26.27,23.37 26.5,23.6 26.5,23.88 26.1,24.29 26.1,24.48 26.53,24.92 27.14,24.92 27.69,25.47 27.69,26.07 27.9,26.29 28.48,26.29 28.8,26.61 28.8,27.19 34.51,32.9 35.75,32.9 38.24,35.39 38.24,37.16 38.92,37.85 38.92,39.17
M_A_DQ7: length 42.2
  IN3 w0.089: 39.23,40.44 39.02,40.64 39.02,43.9 39.57,44.44 40.66,44.44 40.98,44.76 40.98,45.06 41.11,45.19 v2(41.34,45.19)
  IN3 w0.152: 39.23,40.44 39.23,37.6 38.67,37.04 38.67,35.28 37.02,33.63 37.02,33.42 37.12,33.32 37.12,33.14 36.87,32.89 36.69,32.89 36.59,32.99 36.38,32.99 36.16,32.77 36.16,32.56 36.24,32.48 36.24,32.3 35.99,32.05 35.81,32.05 35.36,32.49 34.64,32.49 33.36,31.21 33.36,30.69 32.97,30.3 32.45,30.3 32.04,29.89 32.04,29.39 31.7,29.06 31.21,29.06 30.85,28.7 30.85,28.2 30.49,27.84 29.99,27.84 29.7,27.55 29.7,26.22 25.92,22.43 25.92,20.45 25.56,20.1 23.68,20.1 23.33,19.74 20.81,19.74 20.51,19.44 20.51,18.67 v2(20.01,18.17)
M_A_DQ8: length 37.5
  IN4 w0.152: v2(15.21,21.37) 15.16,21.37 14.36,22.17 14.36,23.47 28.84,37.95 34.88,37.95 36.56,39.63 36.56,42.17 38.4,44.01 v2(39.39,44.01)
M_A_DQ9: length 38.7
  IN4 w0.089: v2(40.04,44.01) 39.92,44.12 39.76,44.12 39.68,44.05 39.68,43.87 39.56,43.74 38.57,43.74
  IN4 w0.152: 38.57,43.74 36.87,42.04 36.87,39.39 35.04,37.57 30.19,37.57 30.06,37.44 30.06,36.76 29.93,36.63 29.58,36.63 29.45,36.76 29.45,37.44 29.32,37.57 29.04,37.57 14.74,23.27 14.74,22.33 14.9,22.17 v2(15.21,22.17)
M_A_DQ10: length 36.4
  IN4 w0.089: v2(39.39,42.65) 39.23,42.65 38.72,42.14 38.72,40.47
  IN4 w0.152: v2(19.21,21.37) 18.11,21.37 17.96,21.52 17.96,23.5 28.35,33.89 28.61,33.89 28.96,33.53 29.14,33.53 29.37,33.76 29.37,33.94 28.99,34.32 28.99,34.53 29.12,34.66 35.45,34.66 38.74,37.95 38.74,40.44 38.72,40.47
M_A_DQ11: length 36.9
  IN4 w0.089: 39.05,40.47 38.92,40.59 38.92,42.07 39.16,42.3 39.4,42.3 39.75,42.65 v2(40.04,42.65)
  IN4 w0.152: v2(20.01,21.37) 20.01,21.63 19.89,21.75 18.62,21.75 18.34,22.03 18.34,23.34 27.49,32.49 27.72,32.49 27.82,32.39 28,32.39 28.24,32.63 28.24,32.81 28.13,32.92 28.13,33.1 28.4,33.38 28.58,33.38 28.94,33.01 29.18,33.01 29.88,33.71 29.88,34.09 30.06,34.28 35.65,34.28 39.08,37.7 39.08,40.44 39.05,40.47
M_A_DQ12: length 38.5
  IN4 w0.089: v2(40.69,43.9) 40.85,43.9 40.96,44.01 40.96,44.17 40.85,44.28 40.42,44.28 40.31,44.17 40.31,43.91 40.19,43.79 40.19,43.79 39.94,43.54 38.77,43.54 38.35,43.12
  IN4 w0.152: v2(16.01,22.97) 16.01,23.78 28.48,36.25 30.31,36.25 30.44,36.38 30.44,37.06 30.57,37.19 30.9,37.19 31.02,37.06 31.02,36.38 31.15,36.25 31.48,36.25 31.61,36.38 31.61,37.06 31.73,37.19 35.2,37.19 37.2,39.19 37.2,41.97 38.35,43.12
M_A_DQ13: length 39.4
  IN4 w0.089: v2(41.34,43.9) 41.05,43.62 40.27,43.62 40.01,43.36 38.92,43.36 37.75,42.19 37.75,42.07 37.7,42.02
  IN4 w0.152: v2(16.01,20.57) 16,20.57 15.63,20.94 15.63,22.33 15.89,22.59 16.4,22.59 16.77,22.96 16.77,24 28.64,35.87 31.89,35.87 32.01,36 32.01,36.68 32.14,36.81 35.42,36.81 37.55,38.94 37.55,41.86 37.7,42.02
M_A_DQ14: length 37.2
  IN4 w0.089: 39.35,40.47 39.35,40.49 39.13,40.72 39.13,41.66 39.84,42.37 40.14,42.37 40.42,42.65 v2(40.69,42.65)
  IN4 w0.152: 39.35,40.47 39.38,40.44 39.38,37.46 35.81,33.89 30.84,33.89 28.79,31.84 27.38,31.84 23.48,27.94 23.48,27.33 23.07,26.93 22.47,26.93 22.08,26.54 22.08,25.94 21.57,25.43 20.97,25.43 20.46,24.92 20.46,24.31 20.15,24.01 19.55,24.01 18.78,23.24 18.78,22.43 18.98,22.23 20.13,22.23 20.38,22.48 20.38,22.86 20.27,22.97 v2(20.01,22.97)
M_A_DQ15: length 38.2
  IN4 w0.089: v2(41.34,42.65) 41.16,42.65 40.9,42.39 40.42,42.39 40.17,42.14 39.89,42.14 39.38,41.64 39.38,40.82 39.68,40.52 39.68,40.47
  IN4 w0.152: 39.68,40.47 39.68,37.23 35.97,33.51 31,33.51 28.95,31.46 27.54,31.46 27.27,31.19 27.27,30.98 27.66,30.59 27.66,30.37 27.44,30.16 27.23,30.16 26.84,30.55 26.62,30.55 26.41,30.33 26.41,30.12 26.8,29.73 26.8,29.51 26.58,29.29 26.37,29.29 25.98,29.68 25.76,29.68 25.49,29.41 25.49,29.2 25.89,28.8 25.89,28.58 25.68,28.36 25.46,28.36 25.06,28.77 24.84,28.77 23.86,27.78 23.86,27.13 21.78,25.05 21.13,25.05 20.84,24.76 20.84,24.11 20.36,23.63 19.7,23.63 19.21,23.13 v2(19.21,22.97)
M_A_DQ16: length 34.8
  IN3 w0.089: 41.28,38.21 41.28,39.4 41.06,39.63 41.06,40.2 41.08,40.23 41.08,41.76 42.06,42.74 42.06,43.02 42.15,43.11 42.53,43.11 42.61,43.03 v2(42.61,42.85)
  IN3 w0.152: 41.28,38.21 41.28,37.39 41.36,37.32 41.36,36.12 41.51,35.97 41.51,30.43 35.06,23.97 35.06,22.47 34.76,22.16 34.76,21.72 35.06,21.42 35.06,21.24 34.84,21.01 34.66,21.01 33.97,21.69 33.79,21.69 33.56,21.46 33.56,21.28 34.24,20.59 34.24,20.41 34.01,20.18 33.83,20.18 33.47,20.54 33.23,20.54 33.11,20.42 33.11,19.86 32.98,19.73 32.6,19.73 32.47,19.86 32.47,20.15 32.34,20.27 30.89,20.27 v2(30.39,19.77)
M_A_DQ17: length 34.1
  IN3 w0.089: v2(42.61,42.2) 42.61,42.14 42.07,41.61 42.07,41.36 41.95,41.23 41.95,39.65 41.79,39.5 41.79,37.88 42.35,37.32 42.35,37.19
  IN3 w0.152: 42.35,37.19 42.35,30.19 41.95,29.78 41.95,29.56 41.98,29.53 41.98,29.31 41.73,29.06 41.52,29.06 41.48,29.1 41.26,29.1 41.01,28.85 41.01,28.63 41.05,28.59 41.05,28.38 40.8,28.12 40.58,28.12 40.54,28.16 40.33,28.16 40.08,27.91 40.08,27.7 40.12,27.66 40.12,27.44 39.86,27.19 39.65,27.19 39.61,27.23 39.39,27.23 39.14,26.98 39.14,26.76 39.29,26.62 39.29,26.44 39,26.15 38.82,26.15 38.68,26.29 38.46,26.29 35.82,23.66 35.82,20.1 34.22,18.5 33.85,18.5 33.72,18.37 33.72,17.73 33.6,17.61 33.23,17.61 33.11,17.73 33.11,18.37 32.98,18.5 32.34,18.5 31.87,18.97 v2(31.19,18.97)
M_A_DQ18: length 36.2
  IN3 w0.089: v2(43.51,44.15) 43.22,44.43 42.38,44.43 39.97,42.02 39.97,41.07 40.03,41.01
  IN3 w0.152: 40.03,41.01 40.42,40.62 40.42,35.97 40.27,35.82 40.27,30.96 39.49,30.18 38.95,30.18 38.69,29.93 38.69,29.39 38.32,29.01 37.78,29.01 37.55,28.78 37.55,28.24 37.07,27.77 36.55,27.77 36.28,27.5 36.28,26.97 31.46,22.15 30.92,22.15 28.64,19.87 28.64,18.86 27.19,17.4 v2(27.19,17.37)
M_A_DQ19: length 37.8
  IN3 w0.089: v2(43.51,45.45) 43.17,45.11 41.98,45.11 39.48,42.62 39.48,40.95 39.81,40.62 39.81,40.44
  IN3 w0.152: 39.81,40.44 39.81,36.99 39.51,36.68 39.51,32.19 39.3,31.98 39.18,31.98 39.06,32.1 38.84,32.1 38.59,31.85 38.59,31.68 38.69,31.58 38.69,31.37 35.74,28.42 35.52,28.42 35.4,28.54 35.18,28.54 34.93,28.29 34.93,28.07 35.52,27.48 35.52,27.29 35.25,27.02 35.03,27.02 34.88,27.17 34.67,27.17 34.42,26.92 34.42,26.7 34.57,26.55 34.57,26.34 33.96,25.73 32.6,25.73 29.49,22.62 29.49,21.8 29.23,21.54 28.86,21.54 26.39,19.07 v2(26.39,18.97)
M_A_DQ20: length 37
  IN3 w0.089: 40.04,40.64 39.66,41.03 39.66,42.4 42.06,44.8 v2(42.61,44.8)
  IN3 w0.152: v2(27.19,18.97) 27.19,18.63 27.32,18.5 27.74,18.5 28.05,18.81 28.05,19 27.77,19.28 27.77,19.91 28.85,20.99 29.22,20.99 30.76,22.53 31.3,22.53 31.49,22.72 31.49,22.9 31.07,23.32 31.07,23.67 32.69,25.29 34.06,25.29 35.9,27.13 35.9,27.72 36.33,28.15 36.92,28.15 37.17,28.4 37.17,28.99 37.58,29.39 38.16,29.39 38.31,29.55 38.31,30.13 38.74,30.56 39.33,30.56 39.89,31.12 39.89,36.43 40.12,36.66 40.12,40.57 40.04,40.64
M_A_DQ21: length 38.4
  IN3 w0.089: v2(42.61,45.45) 42.48,45.32 41.84,45.32 39.25,42.73 39.25,40.77 39.53,40.49
  IN3 w0.152: v2(26.39,17.37) 26.39,18.43 25.98,18.84 25.98,19.38 28.41,21.8 28.41,22.31 32.4,26.3 32.62,26.3 32.72,26.2 32.94,26.2 33.19,26.45 33.19,26.67 33.09,26.77 33.09,26.99 33.34,27.24 33.55,27.24 33.66,27.14 33.87,27.14 34.12,27.39 34.12,27.6 34.02,27.7 34.02,27.92 35.4,29.3 35.61,29.3 35.72,29.2 35.93,29.2 36.18,29.45 36.18,29.66 36.08,29.77 36.08,29.98 36.33,30.23 36.55,30.23 36.65,30.13 36.87,30.13 37.12,30.38 37.12,30.6 37.02,30.7 37.02,30.91 37.27,31.17 37.48,31.17 37.59,31.06 37.8,31.06 38.05,31.32 38.05,31.53 37.95,31.63 37.95,31.85 39.13,33.02 39.13,36.89 39.53,37.29 39.53,40.49
M_A_DQ22: length 35.7
  IN3 w0.089: v2(43.51,42.2) 42.97,42.2 42.64,41.86 42.63,41.86 42.28,41.51 42.28,41.3 42.12,41.15 42.12,38
  IN3 w0.152: v2(31.19,18.17) 32.52,16.84 33.87,16.84 34.82,17.8 34.82,18.56 36.2,19.94 36.2,23.5 38.19,25.48 39.33,25.48 39.91,26.06 39.91,26.28 39.81,26.38 39.81,26.6 40.06,26.85 40.28,26.85 40.38,26.75 40.59,26.75 40.85,27 40.85,27.21 40.74,27.32 40.74,27.53 41,27.78 41.21,27.78 41.31,27.68 41.53,27.68 41.78,27.93 41.78,28.15 41.68,28.25 41.68,28.46 41.93,28.72 42.15,28.72 42.25,28.61 42.46,28.61 42.73,28.88 42.73,37.39 42.12,38
M_A_DQ23: length 36.2
  IN3 w0.089: v2(43.51,43.5) 43.38,43.62 43.15,43.62 43.01,43.48 43.01,42.88 42.63,42.5 42.4,42.5 42.25,42.35 42.25,42.07 41.89,41.71 41.89,41.43 41.77,41.3 41.77,39.73 41.54,39.5
  IN3 w0.152: v2(30.39,17.37) 30.82,17.8 30.82,19.38 31.2,19.77 31.93,19.77 32.47,19.23 32.47,19.03 32.6,18.91 32.93,18.91 33.06,19.03 33.06,19.23 33.18,19.35 33.49,19.35 33.61,19.23 33.61,19 33.74,18.88 34,18.88 34.12,19 34.12,19.23 34.25,19.35 34.54,19.35 35.44,20.26 35.44,23.82 41.95,30.32 41.95,37.14 41.54,37.55 41.54,39.5
M_A_DQ24: length 31.8
  IN4 w0.089: 41.28,40.72 41.59,40.72 41.79,40.92 41.79,41.46 42.22,41.89 42.83,41.89 43.71,42.77 v2(44.45,42.77)
  IN4 w0.152: v2(27.19,20.57) 26.72,21.04 26.72,24.25 29.18,26.71 30.18,26.71 33.42,29.95 34.17,29.95 40.57,36.35 40.57,40.03 40.87,40.33 40.87,40.38 41.21,40.72 41.28,40.72
M_A_DQ25: length 30.8
  IN4 w0.089: v2(44.45,42.2) 44.19,41.94 43.31,41.94 42.94,41.57 42.5,41.57 42,41.06 42,40.87 41.79,40.67 41.79,39.83 41.63,39.67
  IN4 w0.152: v2(27.19,22.97) 27.19,23.18 27.68,23.67 27.68,23.88 27.39,24.17 27.39,24.38 27.61,24.6 27.82,24.6 28.11,24.31 28.32,24.31 28.54,24.53 28.54,24.75 28.26,25.03 28.26,25.25 28.47,25.46 28.69,25.46 28.97,25.18 29.19,25.18 29.4,25.39 29.4,25.61 29.12,25.89 29.12,26.11 29.33,26.33 29.55,26.33 29.83,26.04 30.05,26.04 33.58,29.57 34.33,29.57 40.95,36.19 40.95,38.99 41.63,39.67
M_A_DQ26: length 33.3
  IN4 w0.089: 43.95,38.99 43.95,39.76 44.21,40.01 44.21,40.14 44.46,40.39 44.46,40.72 45.76,42.02 45.76,42.3 45.45,42.6 45.45,43.03 45.76,43.34 45.76,44.07 45.68,44.15 v2(45.4,44.15)
  IN4 w0.152: 43.95,38.99 43.95,38.84 42.96,37.85 42.96,34.5 41.81,33.35 41.59,33.35 41.34,33.6 41.13,33.6 40.91,33.38 40.91,33.17 41.16,32.92 41.16,32.7 40.89,32.43 40.68,32.43 40.43,32.68 40.21,32.68 40,32.46 40,32.25 40.25,32 40.25,31.78 40.03,31.57 39.82,31.57 39.56,31.82 39.35,31.82 39.13,31.6 39.13,31.39 39.38,31.14 39.38,30.92 39.17,30.7 38.95,30.7 38.7,30.96 38.49,30.96 38.27,30.74 38.27,30.52 38.52,30.27 38.52,30.06 36,27.54 34.81,27.54 32.78,25.52 32.78,25.21 33.4,24.6 33.4,24.33 32.04,22.97 v2(31.19,22.97)
M_A_DQ27: length 34.1
  IN4 w0.089: 44.08,38.41 44.08,38.43 44.18,38.54 44.18,39.7 44.38,39.91 44.38,40.03 44.66,40.31 44.66,40.67 45.96,41.97 45.96,44.89 v2(45.4,45.45)
  IN4 w0.152: v2(31.19,21.37) 32.07,21.37 33.89,23.19 33.89,26.08 34.9,27.09 36.12,27.09 41.09,32.07 41.31,32.07 41.65,31.73 41.87,31.73 42.08,31.94 42.08,32.16 41.74,32.5 41.74,32.72 41.96,32.93 42.17,32.93 42.52,32.59 42.73,32.59 42.95,32.81 42.95,33.02 42.6,33.37 42.6,33.58 43.34,34.32 43.34,37.67 44.08,38.41
M_A_DQ28: length 32.9
  IN4 w0.152: v2(26.39,22.17) 26.3,22.26 26.3,22.48 26.17,22.61 25.84,22.61 25.71,22.74 25.71,23.04 25.84,23.17 26.17,23.17 26.3,23.3 26.3,24.44 29.5,27.64 30.57,27.64 33.26,30.33 33.97,30.33 40.27,36.63 40.27,40.37 41.06,41.15 41.06,41.69 41.26,41.89 41.56,41.89 42.28,42.6 42.28,43.62 42.48,43.82 42.73,43.82 43.44,44.53 43.67,44.53 43.94,44.8 v2(44.45,44.8)
M_A_DQ29: length 34.8
  IN4 w0.152: v2(44.45,45.45) 44.01,45.45 43.7,45.14 43.29,45.14 43.09,44.94 43.09,44.71 42.86,44.48 42.48,44.48 41.87,43.87 41.87,42.75 41.28,42.17 40.62,42.17 40.33,41.88 40.1,41.88 39.84,41.61 39.84,40.85 39.96,40.72 39.96,36.86 33.81,30.71 33.11,30.71 30.41,28.02 29.32,28.02 25.33,24.03 25.33,22.43 v2(26.39,21.37)
M_A_DQ30: length 31.1
  IN4 w0.089: v2(45.4,42.19) 45.4,41.91 44.26,40.77 44.26,40.44 43.29,39.48
  IN4 w0.152: v2(30.39,21.37) 30.77,21.75 30.77,23.37 30.97,23.58 31.94,23.58 32.8,24.44 32.8,24.65 32.06,25.39 32.06,25.74 34.29,27.96 35.84,27.96 36.11,28.23 36.11,28.45 35.88,28.68 35.88,28.89 36.1,29.11 36.32,29.11 36.54,28.88 36.76,28.88 36.98,29.1 36.98,29.31 36.75,29.54 36.75,29.76 36.96,29.97 37.18,29.97 37.41,29.74 37.62,29.74 37.84,29.96 37.84,30.17 37.61,30.4 37.61,30.62 42.53,35.54 42.53,38.01 43.24,38.71 43.24,39.43 43.29,39.48
M_A_DQ31: length 33.8
  IN4 w0.089: 43.11,40.39 43.16,40.44 43.35,40.44 43.63,40.72 43.95,40.72 45.12,41.89 45.12,43.21 v2(45.4,43.5)
  IN4 w0.152: 43.11,40.39 42.91,40.19 42.91,38.92 42.15,38.16 42.15,35.7 34.8,28.34 34.13,28.34 31.46,25.67 31.46,25.46 31.69,25.22 31.69,25.01 31.48,24.79 31.26,24.79 31.03,25.03 30.81,25.03 30.6,24.81 30.6,24.59 30.83,24.36 30.83,24.15 30.62,23.93 30.4,23.93 30.17,24.16 29.95,24.16 29.74,23.95 29.74,23.73 29.97,23.5 29.97,23.28 29.75,23.07 28.91,23.07 28.76,22.91 28.76,22.21 28.97,22 29.85,22 30.24,22.38 30.24,22.82 v2(30.39,22.97)
M_A_DQ32: length 30.4
  IN3 w0.089: 42.58,38.31 42.58,39.08 v2(42.58,39.09)
  IN3 w0.152: v2(37.56,18.97) 37.88,18.97 38,19.1 38,19.94 37.88,20.07 37.47,20.07 37.35,20.2 37.35,20.59 37.47,20.72 38.41,20.72 43.57,25.88 43.57,26.27 43.72,26.42 44.26,26.42 44.38,26.55 44.38,26.95 44.26,27.08 43.72,27.08 43.57,27.23 43.57,27.59 43.72,27.74 44.26,27.74 44.38,27.87 44.38,28.45 44.26,28.58 43.7,28.58 43.57,28.71 43.57,29.09 43.7,29.21 44.26,29.21 44.38,29.34 44.38,29.67 44.26,29.8 43.7,29.8 43.57,29.93 43.57,30.28 43.7,30.41 44.26,30.41 44.38,30.54 44.38,30.84 44.26,30.97 43.75,30.97 43.62,31.09 43.62,33.33 44,33.71 44,34.45 43.62,34.83 43.62,35.13 44,35.51 44,36.35 43.62,36.73 43.62,37.27 42.58,38.31
M_A_DQ33: length 31.4
  IN3 w0.089: 42.84,38.46 42.84,39.47 v2(42.58,39.74)
  IN3 w0.152: v2(38.36,18.97) 38.36,18.78 38.57,18.57 38.97,18.57 39.18,18.78 39.18,19.56 38.97,19.77 38.55,19.77 38.39,19.93 38.39,20.16 38.55,20.32 38.97,20.32 39.18,20.53 39.18,20.95 40.18,21.95 40.9,21.95 41.01,22.05 41.01,22.78 41.75,23.52 42.5,23.52 42.63,23.65 42.63,24.4 43.76,25.53 44.56,25.53 44.76,25.73 44.76,31.22 44.64,31.35 44.13,31.35 44,31.48 44,31.88 44.13,32.01 45.17,32.01 45.3,32.14 45.3,32.49 45.17,32.62 44.13,32.62 44,32.75 44,33.05 44.13,33.18 44.68,33.18 44.8,33.3 44.8,33.62 44.38,34.04 44.38,36.43 44,36.81 44,37.29 42.84,38.46
M_A_DQ34: length 31.8
  IN3 w0.152: v2(43.65,38.99) 44.56,38.99 45.58,37.98 45.58,37.77 46.82,36.53 46.82,36.4 46.7,36.28 46.44,36.28 46.31,36.15 46.31,35.89 46.44,35.77 47.1,35.77 47.23,35.64 47.23,35.32 47.1,35.19 46.44,35.19 46.31,35.06 46.31,34.49 47.64,33.17 47.64,33 47.23,32.58 47.23,31.33 47.55,31.01 47.55,30.81 46.54,29.79 46.54,26.98 46.66,26.85 46.8,26.85 46.92,26.73 46.92,26.45 46.8,26.32 46.66,26.32 46.54,26.19 46.54,25.84 46.66,25.71 46.8,25.71 46.92,25.58 46.92,25.33 46.8,25.2 46.66,25.2 46.54,25.07 46.54,24.22 44.64,22.33 44.64,21.6 44.36,21.32 44.16,21.32 43.56,21.91 43.38,21.91 43.12,21.64 43.12,21.46 43.76,20.82 43.76,20.66 43.53,20.42 43.35,20.42 42.82,20.95 42.64,20.95 42.41,20.72 42.41,20.54 42.87,20.09 42.87,19.95 42.68,19.77 41.57,19.77 v2(41.56,19.77)
  BOTTOM w0.216: v2(43.65,38.99) 43.84,38.99 U16.AY56
M_A_DQ35: length 31.9
  IN3 w0.152: v2(43.67,39.43) 44.69,39.43 47.61,36.5 47.61,35.16 47.08,34.62 47.08,34.27 48.02,33.32 48.02,32.84 47.61,32.43 47.61,31.49 48.01,31.09 48.01,30.71 46.92,29.61 46.92,27.57 47.3,27.18 47.3,25.07 46.92,24.69 46.92,24.39 47.3,24.01 47.3,23.73 47.18,23.6 46.45,23.6 45.55,22.7 45.55,21.91 43.03,19.38 42.2,19.38 41.92,19.11 41.92,17.76 42.21,17.47 42.21,17.05 42.02,16.87 41.36,16.87 41.2,17.03 41.2,17.27 41.3,17.37 v2(41.56,17.37)
  BOTTOM w0.216: U16.AW56 43.93,39.68 v2(43.67,39.43)
M_A_DQ36: length 31.5
  IN3 w0.089: v2(42.58,40.54) 42.81,40.31 42.81,39.85 43.02,39.65 43.02,38.68 43.15,38.55
  IN3 w0.152: 43.15,38.55 44.38,37.32 44.38,36.97 44.76,36.59 44.76,34.27 45.27,33.76 45.27,33.09 45.43,32.94 45.78,32.94 45.93,32.79 45.93,31.11 45.78,30.96 45.43,30.96 45.15,30.68 45.15,25.43 44.87,25.15 44.05,25.15 43.01,24.11 43.01,23.86 43.4,23.47 43.4,23.28 43.22,23.1 41.88,23.1 41.39,22.61 41.39,21.72 41.23,21.57 40.35,21.57 39.56,20.78 39.56,18.39 39.35,18.19 38.19,18.19 37.98,17.99 37.98,17.58 38.19,17.37 v2(38.36,17.37)
  BOTTOM w0.216: U16.AV58 42.58,40.54 v2(42.58,40.54)
M_A_DQ37: length 32.6
  IN3 w0.089: 42.38,38.13 42.3,38.21 42.3,41 v2(42.58,41.28)
  IN3 w0.152: 42.38,38.13 43.19,37.32 43.19,36.45 43.62,36.02 43.62,35.7 43.19,35.27 43.19,34.62 43.62,34.19 43.62,33.87 43.19,33.44 43.19,26.04 41.04,23.89 40.21,23.89 39.98,23.66 39.98,22.83 39.37,22.22 38.78,22.22 38.55,21.99 38.55,21.4 38.25,21.1 37.09,21.1 36.97,20.97 36.97,18.72 37.09,18.6 37.49,18.6 37.62,18.47 37.62,18.14 37.49,18.01 36.28,18.01 36.15,17.89 36.15,17.5 36.28,17.37 v2(37.56,17.37)
  BOTTOM w0.216: v2(42.58,41.28) 42.58,41.04 U16.AU58
M_A_DQ38: length 32.4
  IN3 w0.152: v2(42.36,18.97) 42.51,18.83 43.01,18.83 45.24,21.06 46.19,21.06 46.47,21.34 46.47,21.62 46.01,22.08 46.01,22.62 46.23,22.84 47.74,22.84 47.91,23.02 47.91,23.47 47.69,23.7 47.69,27.26 47.9,27.47 47.9,27.74 47.77,27.87 47.43,27.87 47.3,28 47.3,28.48 47.43,28.6 47.79,28.6 47.91,28.73 47.91,29.01 47.79,29.14 47.43,29.14 47.3,29.27 47.3,29.44 47.6,29.74 48.16,29.74 48.39,29.97 48.39,31.24 47.99,31.65 47.99,32.27 48.47,32.75 48.47,33.41 47.58,34.3 47.58,34.5 47.71,34.62 48.35,34.62 48.47,34.75 48.47,35.04 48.35,35.16 48.12,35.16 47.99,35.29 47.99,36.68 44.71,39.96 44,39.96 43.82,40.14 v2(43.82,40.39)
M_A_DQ39: length 33.6
  IN3 w0.152: v2(42.36,18.17) 42.89,18.17 45.2,20.48 46,20.48 46.13,20.35 46.13,20.1 46.26,19.97 46.59,19.97 46.72,20.1 46.72,20.55 46.85,20.68 47.48,20.68 47.61,20.81 47.61,21.11 46.84,21.89 46.84,22.07 47.05,22.28 47.23,22.28 47.76,21.75 48.17,21.75 48.3,21.87 48.3,29.32 48.85,29.87 48.85,31.32 48.37,31.81 48.37,32.11 48.85,32.59 48.85,33.58 48.55,33.89 48.55,34.24 48.85,34.55 48.85,35.39 48.73,35.51 48.5,35.51 48.37,35.64 48.37,35.89 48.5,36.02 48.73,36.02 48.85,36.15 48.85,36.36 44.18,41.04 v2(43.82,41.04)
M_A_DQ40: length 29.7
  IN4 w0.089: v2(45.01,39.09) 44.95,39.03 44.95,36.75
  IN4 w0.152: 44.95,36.75 44.95,36.38 45.07,36.25 45.3,36.25 45.43,36.12 45.43,35.82 45.3,35.69 45.07,35.69 44.95,35.56 44.95,35.31 45.07,35.18 45.3,35.18 45.43,35.06 45.43,34.77 45.3,34.64 45.07,34.64 44.95,34.51 44.95,31.35 44.78,31.18 44.58,31.18 44.18,31.58 44,31.58 43.76,31.34 43.76,31.16 44.17,30.75 44.17,30.57 43.97,30.37 43.79,30.37 43.38,30.78 43.2,30.78 42.96,30.54 42.96,30.36 43.37,29.95 43.37,29.77 43.16,29.56 42.98,29.56 42.56,29.97 42.38,29.97 42.16,29.74 42.16,29.56 42.58,29.14 42.58,28.98 39.51,25.91 38.86,25.91 38.22,25.26 38.22,24.06 38.08,23.93 37.7,23.93 37.58,23.8 37.58,23.52 37.7,23.4 38.69,23.4 38.9,23.19 38.9,22.79 38.7,22.59 38.29,22.59 37.93,22.23 37.93,20.76 38.12,20.57 v2(38.36,20.57)
M_A_DQ41: length 31.2
  IN4 w0.089: v2(45.01,39.74) 45.01,39.62 44.74,39.35 44.74,38 44.56,37.83 44.56,37.77
  IN4 w0.152: 44.56,37.77 44.56,32.31 44.36,32.11 43.99,32.11 41.71,29.83 41.72,29.82 41.72,29.46 42.03,29.15 42.03,28.97 41.82,28.76 41.64,28.76 41.23,29.17 41.05,29.17 40.83,28.96 40.83,28.8 41.26,28.38 41.26,28.2 41.06,28 40.88,28 40.47,28.41 40.29,28.41 40.09,28.21 40.09,28.03 40.5,27.62 40.5,27.44 40.32,27.26 40.09,27.26 39.7,27.65 39.52,27.65 39.31,27.43 39.31,27.25 39.66,26.9 39.66,26.67 39.44,26.46 38.37,26.46 37.61,25.7 36.97,25.7 36.84,25.58 36.84,25.28 36.97,25.15 37.71,25.15 37.83,25.02 37.83,24.74 37.71,24.62 36.51,24.62 36.36,24.46 36.36,24.21 36.48,24.08 37.07,24.08 37.2,23.96 37.2,23.68 37.07,23.55 36.48,23.55 36.36,23.42 36.36,23.1 36.48,22.97 v2(38.36,22.97)
M_A_DQ42: length 31.1
  IN4 w0.089: 46.36,38.01 v2(46.36,39.09)
  IN4 w0.152: v2(42.36,22.97) 43.16,22.17 43.16,20.86 43.29,20.73 44.64,20.73 44.76,20.86 44.76,21.09 44.46,21.39 44.46,21.9 44.59,22.03 45.17,22.03 45.3,21.9 45.3,20.82 45.43,20.69 45.7,20.69 45.83,20.82 45.83,24.72 45.65,24.9 45.65,25.93 45.3,26.28 45.3,26.62 45.4,26.73 45.81,26.73 45.93,26.85 45.93,27.92 45.85,28.01 45.53,28.01 45.35,28.18 45.35,28.44 45.85,28.95 46.03,28.95 46.18,28.79 46.36,28.79 46.56,28.99 46.56,29.17 46.41,29.32 46.41,29.5 46.61,29.71 46.79,29.71 46.94,29.55 47.12,29.55 47.3,29.73 47.3,29.91 47.15,30.05 47.15,30.23 47.35,30.43 47.53,30.43 47.69,30.28 47.85,30.28 48.19,30.62 48.19,36.17 46.36,38.01
M_A_DQ43: length 30.8
  IN4 w0.089: 46.29,37.65 46.09,37.85 46.09,39.46 v2(46.36,39.74)
  IN4 w0.152: v2(42.36,21.37) 42.65,21.37 42.78,21.5 42.78,21.72 42.65,21.85 41.68,21.85 41.55,21.98 41.55,22.25 41.68,22.38 41.97,22.38 42.1,22.51 42.1,22.7 41.97,22.83 41.97,23.24 42.08,23.35 42.68,23.35 42.78,23.25 42.78,23.09 43.54,22.33 43.54,21.24 43.67,21.11 43.95,21.11 44.08,21.24 44.08,22.28 44.21,22.41 45.27,22.41 45.45,22.59 45.45,24.54 45.27,24.72 45.27,25.77 44.92,26.13 44.92,26.98 45.04,27.11 45.43,27.11 45.55,27.23 45.55,27.51 45.43,27.64 45.09,27.64 44.97,27.77 44.97,28.6 47.18,30.81 47.7,30.81 47.81,30.93 47.81,36.12 46.29,37.65
M_A_DQ44: length 31.7
  IN4 w0.089: 44.28,37.7 44.28,37.8 44.54,38.05 44.54,39.45 44.74,39.65 44.74,39.88 45.11,40.26 v2(45.11,40.39)
  IN4 w0.152: v2(37.56,22.17) 37.28,22.46 36.66,22.46 36.55,22.34 36.55,21.94 36.43,21.82 36.1,21.82 35.98,21.95 35.98,22.71 35.85,22.84 35.06,22.84 34.93,22.97 34.93,23.25 35.06,23.37 35.85,23.37 35.98,23.5 35.98,23.78 35.85,23.91 35.14,23.91 35.01,24.03 35.01,24.31 35.14,24.44 35.79,24.44 36.38,25.03 36.38,25.66 36.81,26.08 37.46,26.08 38.23,26.86 38.23,26.99 38.01,27.21 38.01,27.44 38.21,27.64 38.39,27.64 38.6,27.43 38.78,27.43 38.98,27.63 38.98,27.81 38.84,27.95 38.84,28.13 39.04,28.33 39.22,28.33 39.37,28.19 39.55,28.19 39.75,28.39 39.75,28.57 39.6,28.72 39.6,28.9 39.8,29.1 39.98,29.1 40.13,28.95 40.31,28.95 40.51,29.15 40.51,29.33 40.34,29.5 40.34,29.68 40.54,29.88 40.72,29.88 40.92,29.68 41.1,29.68 41.3,29.88 41.3,30.06 41.06,30.31 41.06,30.46 41.27,30.67 42.01,30.67 44.18,32.84 44.18,37.49 44.28,37.6 44.28,37.7
M_A_DQ45: length 31.7
  IN4 w0.089: v2(45.41,41.03) 45.3,41.03 44.84,40.57 44.84,40.24 44.56,39.96 44.56,39.73 44.36,39.53 44.36,38.26 44.28,38.18
  IN4 w0.152: v2(37.56,21.37) 37.19,21.75 36.9,21.75 36.52,21.37 34.83,21.37 34.55,21.65 34.55,24.97 34.88,25.3 35.06,25.3 35.5,24.87 35.68,24.87 35.96,25.14 35.96,25.32 35.57,25.71 35.57,25.91 36.13,26.47 37.29,26.47 37.3,26.47 37.65,26.82 37.65,27.07 37.35,27.38 37.35,27.63 37.84,28.12 38.29,28.12 38.58,28.41 38.58,28.87 38.83,29.13 39.29,29.13 39.56,29.39 39.56,29.89 39.9,30.23 40.4,30.23 40.57,30.41 40.57,30.9 41.04,31.37 41.26,31.37 41.54,31.09 41.89,31.09 43.8,33 43.8,37.7 44.28,38.18
  BOTTOM w0.216: U16.AU54 45.12,41.03 v2(45.41,41.03)
M_A_DQ46: length 31.1
  IN4 w0.089: 46.53,37.03 45.91,37.65 45.91,39.65 46.16,39.91 46.16,40.31 46.23,40.39 v2(46.36,40.39)
  IN4 w0.152: 46.53,37.03 47,36.56 47,36.12 47.11,36.01 47.3,36.01 47.43,35.88 47.43,35.59 47.3,35.46 47.13,35.46 47,35.34 47,35.01 47.13,34.88 47.3,34.88 47.43,34.75 47.43,31.61 44.59,28.76 44.59,28.3 44.46,28.17 44,28.17 43.87,28.05 43.87,27.69 44,27.56 44.39,27.56 44.52,27.44 44.52,27.03 44.39,26.9 44.04,26.9 43.92,26.78 43.92,26.59 44.89,25.61 44.89,25.06 44.79,24.96 44.2,24.96 43.7,24.46 43.7,23.47 43.82,23.35 44.26,23.35 44.36,23.45 44.36,24.08 44.49,24.21 44.94,24.21 45.07,24.08 45.07,22.92 44.94,22.79 43.63,22.79 43.16,23.25 43.16,23.93 43.04,24.06 42.71,24.06 42.38,23.73 41.7,23.73 41.56,23.6 v2(41.56,22.97)
M_A_DQ47: length 31.8
  IN4 w0.089: v2(46.36,41.04) 46.46,40.93 46.46,40.82 46.36,40.72 46.09,40.72 45.96,40.59 45.96,39.96 45.7,39.71 45.7,37.32 45.96,37.06 46.11,37.06 46.34,36.83
  IN4 w0.152: 46.34,36.83 46.62,36.56 46.62,34.73 47.05,34.29 47.05,33.99 46.92,33.86 46.32,33.86 46.19,33.74 46.19,33.38 46.32,33.25 46.92,33.25 47.05,33.13 47.05,32.82 46.92,32.69 46.32,32.69 46.19,32.57 46.19,32.24 46.32,32.11 46.82,32.11 46.95,31.98 46.95,31.66 46.82,31.53 46.44,31.53 46.31,31.41 46.31,31.02 43.49,28.2 43.49,26.48 44.2,25.76 44.2,25.58 43.97,25.34 43.79,25.34 43.13,25.99 42.95,25.99 42.73,25.77 42.73,25.59 43.42,24.9 43.42,24.72 43.2,24.5 43.02,24.5 42.35,25.18 42.17,25.18 41.94,24.95 41.94,24.77 42.21,24.51 42.21,24.33 41.99,24.11 41.81,24.11 41.54,24.39 41.3,24.39 41.17,24.26 41.17,21.48 41.28,21.37 v2(41.56,21.37)
M_A_DQ48: length 34.1
  IN3 w0.152: v2(53.54,18.17) 54.33,18.17 54.95,18.79 54.95,37.13 54.67,37.41 54.67,38.25 55.74,39.32 55.74,39.91 56.42,40.59 56.42,40.97 56.3,41.1 55.84,41.1 55.71,41.23 55.71,41.52 55.84,41.64 56.3,41.64 56.42,41.77 56.42,42.78 56.55,42.91 57.31,42.91 57.44,43.03 57.44,43.29 57.31,43.41 56.47,43.41 56.35,43.54 56.35,44.72 55.75,45.32 54.04,45.32 v2(53.91,45.45)
M_A_DQ49: length 33.6
  IN3 w0.152: v2(52.74,17.37) 52.76,17.37 53.17,17.78 53.17,18.37 53.38,18.57 54.19,18.57 54.57,18.95 54.57,23.12 54.39,23.3 54.39,26.87 54.57,27.05 54.57,36.98 54.28,37.26 54.28,38.51 54.06,38.73 54.06,39.58 54.19,39.7 54.7,39.7 54.82,39.83 54.82,40.11 54.7,40.24 54.19,40.24 54.06,40.37 54.06,40.97 54.19,41.1 54.46,41.1 54.59,41.23 54.59,42.8 54.55,42.84 54.55,43.46 54.68,43.59 55.08,43.59 55.2,43.72 55.2,44.81 55.08,44.94 53.58,44.94 v2(53.07,45.45)
M_A_DQ50: length 32.2
  IN3 w0.152: v2(52.12,44.15) 51.43,43.46 50.47,43.46 49.26,42.26 49.26,41.84 50.01,41.09 50.01,40.44 50.81,39.64 50.81,37.24 51.91,36.14 51.91,35.65 51.52,35.26 51.52,34.91 51.91,34.52 51.91,34.25 51.52,33.86 51.52,33.59 51.91,33.2 51.91,32.93 51.52,32.54 51.52,32.27 51.91,31.88 51.91,31.61 51.52,31.22 51.52,30.87 51.91,30.48 51.91,29.68 51.52,29.29 51.52,27.26 51.14,26.88 51.14,26.24 51.52,25.86 51.52,25.48 51.14,25.1 51.14,21.8 50.16,20.82 50.16,18.53 49.87,18.24 49.87,17.7 v2(49.54,17.37)
M_A_DQ51: length 31
  IN3 w0.152: v2(51.14,44.15) 51.14,44 51.04,43.9 50.36,43.9 48.88,42.42 48.88,41.2 48.55,40.87 48.55,40.47 49.36,39.65 49.79,39.65 50.02,39.43 50.02,37.39 51.14,36.28 51.14,35.83 50.99,35.68 50.86,35.68 50.71,35.53 50.71,35.17 50.86,35.02 50.99,35.02 51.14,34.87 51.14,34.51 50.99,34.36 50.86,34.36 50.71,34.21 50.71,33.85 50.86,33.7 50.99,33.7 51.14,33.55 51.14,33.19 50.99,33.04 50.86,33.04 50.71,32.89 50.71,32.53 50.86,32.38 50.99,32.38 51.14,32.22 51.14,31.87 50.99,31.72 50.86,31.72 50.71,31.56 50.71,31.21 50.86,31.06 50.99,31.06 51.14,30.9 51.14,29.87 49.87,28.6 49.87,27.92 50.25,27.54 50.25,21.51 49.78,21.04 49.78,19.21 v2(49.54,18.97)
M_A_DQ52: length 31.1
  IN3 w0.152: v2(48.74,18.97) 48.74,20.29 48.98,20.53 48.98,29.29 49.39,29.7 49.39,32.57 49.54,32.72 49.72,32.72 49.87,32.87 49.87,33.23 49.72,33.38 49.54,33.38 49.39,33.54 49.39,33.89 49.54,34.04 49.72,34.04 49.87,34.2 49.87,34.55 49.72,34.7 49.54,34.7 49.39,34.86 49.39,35.21 49.54,35.36 49.72,35.36 49.87,35.52 49.87,36.12 47.46,38.54 47.46,40.75 47.28,40.92 47.28,41.66 47.71,42.09 47.71,42.33 50.83,45.45 v2(51.14,45.45)
M_A_DQ53: length 33.5
  IN3 w0.152: v2(48.74,17.37) 49.18,17.82 49.18,19.64 49.4,19.85 49.4,29 49.92,29.52 50.17,29.52 50.33,29.67 50.33,30.03 50.17,30.18 49.92,30.18 49.77,30.33 49.77,30.69 49.92,30.84 50.17,30.84 50.33,30.99 50.33,31.35 50.17,31.5 49.92,31.5 49.77,31.65 49.77,32.01 49.92,32.16 50.17,32.16 50.33,32.31 50.33,36.21 47.99,38.54 47.99,39.76 48.17,39.93 48.17,41.15 48.5,41.48 48.5,42.57 50.84,44.91 51.58,44.91 v2(52.12,45.45)
M_A_DQ54: length 32.6
  IN3 w0.152: v2(53.54,18.97) 53.9,18.97 54.19,19.26 54.19,19.99 54.06,20.12 53.68,20.12 53.55,20.25 53.55,20.58 53.68,20.71 54.06,20.71 54.19,20.83 54.19,22.84 53.83,23.19 53.83,26.85 54.19,27.21 54.19,36.35 54.06,36.48 53.65,36.48 53.52,36.61 53.52,36.91 53.65,37.04 53.78,37.04 53.9,37.16 53.9,37.45 53.78,37.58 53.3,37.58 53.17,37.7 53.17,38.02 53.3,38.15 53.55,38.15 53.68,38.28 53.68,39.58 53.43,39.83 53.1,39.83 52.97,39.96 52.97,40.21 53.17,40.41 53.17,40.78 53.45,41.06 53.45,41.33 53.25,41.53 53.03,41.53 52.66,41.9 52.66,42.47 53.34,43.14 54,43.14 54.14,43.29 54.14,43.59 54.76,44.21 54.76,44.45 54.66,44.56 54.01,44.56 53.88,44.43 v2(53.88,44.15)
M_A_DQ55: length 31.8
  IN3 w0.152: v2(52.74,19.77) 53.17,20.2 53.17,23.07 53.45,23.35 53.45,27.01 53.81,27.37 53.81,28.02 53.68,28.15 53.32,28.15 53.19,28.27 53.19,28.66 53.32,28.78 53.68,28.78 53.81,28.91 53.81,30.84 53.68,30.97 53.32,30.97 53.2,31.09 53.2,31.43 53.32,31.55 53.68,31.55 53.81,31.68 53.81,33.84 53.68,33.96 53.27,33.96 53.14,34.09 53.14,34.37 53.27,34.5 53.68,34.5 53.81,34.62 53.81,34.9 53.68,35.03 53.27,35.03 53.14,35.16 53.14,35.44 53.27,35.56 53.68,35.56 53.81,35.69 53.81,35.97 53.68,36.1 53.27,36.1 53.14,36.22 53.14,37.2 52.41,37.93 52.41,38.31 52.54,38.43 53.05,38.43 53.17,38.56 53.17,38.82 53.05,38.94 52.54,38.94 52.41,39.07 52.41,40.47 52.03,40.85 52.03,41.67 52.28,41.92 52.28,42.63 53.43,43.77 53.43,44.02 53.3,44.15 v2(53.07,44.15)
