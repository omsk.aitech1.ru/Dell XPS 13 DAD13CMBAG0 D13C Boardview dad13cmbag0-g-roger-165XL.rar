# Allegro board dad13cmbag0-g-roger-165XL.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
CFG1: length 5.6
  TOP w0.127: R109.1 37.55,47.76 v7(37.7,47.6) 37.86,47.45 38.08,47.45 38.57,47.93 38.57,48.21 38.49,48.29 v6(38.03,48.29)
  BOTTOM w0.127: v6(38.03,48.29) 38.03,48.59 38.34,48.9 39.08,48.9 39.1,48.92 39.67,48.92 U16.AC62
CFG2: length 6.3
  BOTTOM w0.127: TP103.1 34.29,48.18 36.95,48.18 38.07,49.29 U16.AC63
CFG3: length 8.6
  IN4 w0.089: v2(32.8,49.89) 32.95,49.74 36.41,49.74 36.71,50.04 v2(39.39,50.04)
  BOTTOM w0.127: v6(32.75,51.62) 32.68,51.55 R300.1 32.68,50.01 v2(32.8,49.89)
CFG4: length 5.6
  TOP w0.127: v4(39.46,49.48) 39.46,49.28 39.33,49.15 39.05,49.15 38.85,49.36 R101.1
  IN1 w0.089: v4(39.46,49.48) 39.53,49.56 39.66,49.56 39.75,49.47 39.75,49.34 39.84,49.26 40.02,49.26 40.11,49.34 40.11,49.47 40.2,49.56 40.38,49.56 40.46,49.47 40.46,49.34 40.55,49.26 40.73,49.26 40.82,49.34 40.82,49.47 40.91,49.56 41.13,49.56 41.2,49.5 41.2,49.37 41.28,49.28 41.64,49.28 41.74,49.38 v5(41.74,49.94)
  IN4 w0.089: v2(41.34,50.08) 41.47,49.94 v5(41.74,49.94)
CFG5: length 7.3
  BOTTOM w0.127: U16.Y62 39.89,50.93 39.69,51.13 39.13,51.13 38.9,50.91 37.42,50.91 36.52,50 34.64,50 TP98.1
CFG6: length 6.4
  BOTTOM w0.127: TP99.1 35.53,49.62 36.78,49.62 37.58,50.42 40.36,50.42 U16.Y61
CFG7: length 7.9
  IN4 w0.089: v2(35.04,47.65) 35.72,48.34 37.07,48.34 37.63,48.9 40.02,48.9 40.98,49.86 40.98,50.39 v2(41.34,50.75)
CFG8: length 6
  TOP w0.127: v4(39.08,52.02) 38.92,52.02 38.77,51.87 v7(38.77,51.52) 38.77,51.36 38.57,51.16 38.19,51.16 38.11,51.24 38.11,52.18 37.96,52.33 37.74,52.33 R88.1
  IN1 w0.089: v4(39.08,52.02) 39.08,51.19 39.13,51.13 39.39,51.13 39.48,51.22 39.48,51.72 39.58,51.82 v5(39.76,51.82)
  IN4 w0.089: v2(40.04,51.54) 39.76,51.81 v5(39.76,51.82)
CFG9: length 6.1
  TOP w0.127: R83.1 v7(38.49,53.04) 38.69,53.04 v4(39.08,52.66)
  IN1 w0.089: v4(39.08,52.66) 39.46,52.66 39.79,52.33 40.83,52.33 41.23,51.92 41.23,51.54 40.95,51.26 v5(40.37,51.26)
  IN4 w0.089: v5(40.37,51.26) 40.37,51.26 v2(40.69,51.57)
CFG10: length 5.8
  TOP w0.127: v4(39.46,50.5) 39.33,50.63 R96.1
  IN1 w0.089: v4(39.46,50.5) 39.6,50.5 39.69,50.41 39.69,50 39.78,49.92 39.96,49.92 40.04,50 40.04,50.41 40.13,50.5 40.4,50.5 40.47,50.42 40.47,50 40.56,49.92 40.78,49.92 40.88,50.02 40.88,50.58 v5(41.62,51.31)
  IN4 w0.089: v5(41.62,51.31) 41.35,51.57 v2(41.34,51.57)
CFG11: length 6.8
  IN4 w0.089: v2(41.34,52.25) 40.98,51.89 40.98,51.11 39.57,49.69 36.9,49.69 v2(36.31,49.1)
CFG12: length 5.9
  BOTTOM w0.127: TP85.1 36.74,52.4 36.79,52.46 36.79,52.83 36.93,52.97 37.18,52.97 37.18,52.97 37.27,52.88 37.27,52.23 37.39,52.1 37.65,52.1 37.77,52.23 37.77,52.93 37.85,53.01 38.06,53.01 38.19,52.89 38.19,52.58 38.29,52.48 38.44,52.48 38.59,52.63 38.59,52.91 38.72,53.03 U16.T63
CFG13: length 6.1
  BOTTOM w0.127: TP90.1 35.29,50.53 36.46,51.69 38.21,51.69 39.15,52.63 39.63,52.63 U16.T62
CFG14: length 5.5
  BOTTOM w0.127: TP82.1 36.1,53.62 36.1,53.27 36.26,53.12 36.51,53.12 36.84,53.45 38.74,53.45 38.8,53.4 40.37,53.4 40.69,53.08 U16.T61
CFG15: length 8.1
  TOP w0.127: TP19.1 35.82,51.03 v4(35.52,51.34)
  IN1 w0.089: v5(35.54,50.8) 35.52,50.83 v4(35.52,51.34)
  IN4 w0.089: v5(35.54,50.8) 37.73,50.8 40.04,53.12 41.29,53.12 v2(41.34,53.07)
CFG16: length 8.4
  BOTTOM w0.127: U16.AA62 39.69,49.69 37.91,49.69 36.79,48.57 33,48.57 TP97.1
CFG17: length 4.1
  BOTTOM w0.127: TP91.1 36.28,50.96 36.64,51.31 38.41,51.31 U16.U63
CFG18: length 9.5
  IN4 w0.089: v2(32.5,47.65) 32.83,47.32 33.84,47.32 35.27,48.75 36.89,48.75 37.5,49.35 39.96,49.35 v2(40.69,50.08)
CFG19: length 7.4
  IN4 w0.089: v2(33.74,50.23) 36.29,50.23 36.51,50.45 37.88,50.45 39.72,52.29 v2(40.04,52.29)
  BOTTOM w0.127: v2(33.74,50.23) 33.74,50.23 TP92.1
CHARGER_AGND: length 6.6
  TOP w0.254: v4(130.74,31.3) 131.02,31.3 131.03,31.29 133.65,31.29 133.83,31.11 PC86.2 PC90.2
  IN1 w0.254: PU12.22 128.87,31.3 v4(130.74,31.3)
  vias: v6(124.04,28.66) v6(124.8,28.66) v6(128.1,37.03) v6(128.86,37.03) v6(133.39,37.04) v7(123.53,28.02)
CLK_33M_TPM_TPM: length 3.2
  TOP w0.127: R53.1 154.22,57.98 153.07,56.83 U6.21
CLK_PCIE_WLANN: length 148.9
  IN4 w0.089: v2(170.3,23.24) 170.09,23.24 169.96,23.37 169.96,24.8 168.13,26.63 168.13,33.82 167.09,34.86 167.09,37.08 163.91,40.26 162.13,40.26 161.63,40.77 160.86,40.77 156.89,44.73 155.36,44.73 154.76,45.34 142.16,45.34 141.23,44.42 132.27,44.42 131.42,45.27 113.43,45.27 111.89,46.8 101.78,46.8 101.43,47.15 96.23,47.15 96.08,46.99 95.01,46.99 94.84,47.17 84.74,47.17 84,47.91 80.99,47.91 80.46,47.38 73.77,47.38 73.69,47.45 71.43,47.45 68.74,50.14 68.74,53.07 66.55,55.27 66.11,55.27 65.06,56.33 65.06,57.75 64.46,58.35 57.57,58.35 56.65,59.27 56.65,59.6 56,60.25 54.41,60.25 v2(54.24,60.43)
  BOTTOM w0.102: v2(54.24,60.43) 54.24,60.33 54.19,60.28 53.93,60.28 53.8,60.41 U16.C41 ; CN4.49 172.08,25.4 171.91,25.58 171.63,25.58 v7(171.1,25.05) 170.58,25.58 170.46,25.58 169.99,25.1 169.99,23.3 170.05,23.24 v2(170.3,23.24)
CLK_PCIE_WLANP: length 149.1
  IN4 w0.089: v2(169.63,23.24) 169.73,23.34 169.73,24.71 167.9,26.54 167.9,33.73 166.86,34.77 166.86,36.99 163.81,40.03 162.04,40.03 161.53,40.54 160.76,40.54 156.79,44.51 155.27,44.51 154.66,45.11 142.25,45.11 141.32,44.19 132.18,44.19 131.33,45.04 113.33,45.04 111.8,46.58 101.68,46.58 101.34,46.92 96.33,46.92 96.17,46.77 94.92,46.77 94.74,46.94 84.64,46.94 83.91,47.68 81.09,47.68 80.55,47.15 79.54,47.15 79.49,47.2 73.7,47.2 73.62,47.27 71.28,47.27 68.51,50.04 68.51,52.98 66.45,55.04 66.02,55.04 64.83,56.23 64.83,57.65 64.36,58.12 57.48,58.12 56.42,59.18 56.42,59.51 55.91,60.02 54.27,60.02 v2(54.24,59.99)
  BOTTOM w0.102: U16.B42 52.71,60.54 53.15,60.1 53.81,60.1 53.84,60.06 54.16,60.06 v2(54.24,59.99) ; v2(169.63,23.24) 169.77,23.38 169.77,25.19 170.37,25.79 170.58,25.79 v7(171.1,26.32) 171.63,25.79 171.96,25.79 172.07,25.9 CN4.47
CLKDVCOM: length 2.9
  BOTTOM w0.127: TP95.1 192.67,50.63 192.67,50.78 191.85,51.6 J1.22
CLKRUN#: length 102.3
  TOP w0.127: U4.D8 v9(138.41,58.48) ; v4(90.08,46.94) 90.05,46.97 88.71,46.97 87.36,48.32 v7(86.95,48.32) 86.83,48.32 86.54,48.03 84.18,48.03 84.08,47.93 81.72,47.93 81.24,48.42 81.24,50.7 80.99,50.96 80.1,50.96 79.86,51.19 R92.1 79.56,51.52 79.33,51.29 v4(79.33,51.03)
  IN1 w0.089: v9(138.41,58.48) 138.1,58.78 137.4,58.78 137.04,59.14 135.39,59.14 135.26,59.26 134.86,59.26 134.48,59.64 134.48,60 133.98,60.49 131.64,60.49 131.2,60.05 131,60.05 130.62,59.67 130.5,59.67 129.61,58.78 126.79,58.78 125.6,57.59 125.16,57.59 123.73,56.16 123.73,55.72 123.52,55.5 123.07,55.5 121.55,53.98 119.69,53.98 118.62,52.9 116.35,52.9 115.75,52.3 107.34,52.3 106.84,51.8 102.94,51.8 102.2,51.06 94.14,51.06 90.97,47.88 90.36,47.88 90.08,47.6 v4(90.08,46.94) ; v4(79.33,51.03) 79.02,51.03 v5(78.67,50.68) ; v9(159.6,56.98) 160.61,57.99 v4(160.61,58.75)
  IN2 w0.089: v9(138.41,58.48) 138.41,59.53 138.9,60.02 144.31,60.02 148.17,56.16 158.79,56.16 v9(159.6,56.98)
  IN4 w0.089: v2(75.38,51.57) 75.59,51.35 75.59,51.28 75.91,50.96 76.72,50.96 76.86,51.1 77.57,51.1 77.77,50.89 77.77,50.51 77.96,50.32 78.31,50.32 v5(78.67,50.68)
CLKRUN#_TPM: length 5.9
  TOP w0.127: U6.15 156.97,56.38 157.19,56.6 157.72,56.6 157.92,56.39 159.06,56.39 v7(159.6,56.93) R57.1 R58.1
CONFIG2: length 3.2
  BOTTOM w0.127: CN1.6 207.61,63.4 207.43,63.58 TP64.1
CRIT_TEMP_REP_N: length 11.7
  BOTTOM w0.076: 77.43,53.34 77.36,53.27 77.28,53.27 77.02,53.12 U16.T3
  BOTTOM w0.127: 77.43,53.34 78.88,53.34 80.88,55.35 82.05,55.35 82.64,54.77 84.06,54.77 84.66,54.17 R286.1 84.99,54.17 85.43,54.61 TP79.1
DATADVCOM: length 3.2
  TOP w0.127: TP17.1 196.48,51.72 v6(197.24,50.96)
  BOTTOM w0.127: v6(197.24,50.96) 197.75,51.46 198.18,51.46 198.35,51.64 J1.9
DC_TEST_A3_B3: length 0.7
  BOTTOM w0.127: U16.A3 76.88,61.19 U16.B3
DC_TEST_A61_B61: length 0.7
  BOTTOM w0.127: U16.A61 40.63,61.12 U16.B61
DC_TEST_AY2_AW2: length 0.7
  BOTTOM w0.127: U16.AY2 77.47,39.63 U16.AW2
DC_TEST_AY3_AW3: length 0.7
  BOTTOM w0.127: U16.AW3 76.69,39.4 76.75,39.35 U16.AY3
DC_TEST_AY61_AW61: length 0.7
  BOTTOM w0.127: U16.AY61 40.61,39.65 U16.AW61
DC_TEST_AY62_AW62: length 0.7
  BOTTOM w0.127: U16.AW62 39.95,39.65 U16.AY62
DC_TEST_B62_B63: length 0.7
  BOTTOM w0.127: U16.B62 39.52,60.99 U16.B63
DC_TEST_C1_C2: length 0.7
  BOTTOM w0.127: U16.C1 77.49,60.58 U16.C2
DDC_EN#: length 12.1
  TOP w0.127: v7(195.26,65.56) 195.33,65.49 R9.1 197.08,65.49 Q2.3 199.05,63.52 U2.1 199.05,59.53 198.4,58.88 U2.7
DDR3_DRAMRST#: length 156.1
  IN4 w0.089: v6(53.94,10.57) 55.23,11.86 55.23,15.38 55.55,15.69 55.55,18.11 55.33,18.32 v2(55.33,33.53) ; v6(53.94,10.57) 54.34,10.17 56.01,10.17 56.91,9.28 62.14,9.28 62.8,8.61 v2(62.81,8.61) 62.81,8.61 64.2,7.21 69.83,7.21 71.33,8.72 v2(71.84,8.72) 71.84,8.23 72.12,7.95 84.13,7.95 v2(84.97,8.79) 86.55,7.21 88.24,7.21 88.38,7.07 91.73,7.07 94.78,10.11 96.73,10.11 97.24,10.62 97.24,11.09 v6(96.96,11.37) ; v6(53.94,10.57) 53.48,10.11 51.65,10.11 48.14,6.61 43.37,6.61 v2(41.16,8.82) 38.92,8.82 38.06,7.95 30.44,7.95 29.93,8.46 29.93,9.48 30.31,9.86 30.57,9.86 31.19,10.48 v2(31.19,10.97) 30.58,10.37 29.37,10.37 26.22,7.21 22.84,7.21 22.44,6.81 20.81,6.81 v2(19.05,8.58)
  BOTTOM w0.127: v2(55.33,33.53) 60.72,33.53 65.26,38.08 67.68,38.08 68.46,38.87 68.46,40.19 68.66,40.39 U16.AV15 ; v2(41.16,8.82) 41.26,8.92 41.87,8.92 42.36,9.42 U20.T2 ; C262.1 R356.1 55.59,8.93 v6(53.94,10.57) U21.T2 ; U18.T2 20.01,9.54 v2(19.05,8.58) ; v2(62.81,8.61) 63.03,8.61 63.83,9.42 U22.T2 ; U23.T2 74.27,10.24 73.01,10.24 71.84,9.07 v2(71.84,8.72) ; v2(84.97,8.79) 86.18,10 U24.T2
  BOTTOM w0.216: U25.T2 v6(96.96,11.37)
DDR_PG_CTRL: length 124
  TOP w0.127: v9(116.47,56.65) 116.47,56.67 116.29,56.49 116.29,53.52 117.15,52.66 117.15,45.47 118.35,44.28 PR50.1
  IN1 w0.089: v6(25.49,39.58) 27.24,41.33 30.36,41.33 38.29,49.26 38.29,54.56 39,55.27 41.67,55.27 42.2,55.81 42.2,56.57 44.32,58.69 56.96,58.69 57.31,58.35 68.49,58.35 68.89,57.94 70.37,57.94 70.7,58.27 71.71,58.27 72.48,59.03 75.86,59.03 76.13,59.31 76.69,59.31 79.45,56.54 83.95,56.54 84.5,57.09 91.19,57.09 91.63,57.54 102.98,57.54 103.45,57.07 109.8,57.07 110.88,58.15 v9(111.85,58.15)
  IN2 w0.089: v9(116.47,56.65) 116.27,56.85 114.82,56.85 113.52,58.15 v9(111.85,58.15)
  BOTTOM w0.127: U17.4 24.49,40.71 24.47,40.72 R345.2 23.72,40.33 v7(24.6,39.45) 25.36,39.45 v6(25.49,39.58)
DEVSLP0: length 13
  BOTTOM w0.076: U16.P2 77.36,53.8
  BOTTOM w0.127: 77.36,53.8 77.36,53.92 77.3,53.98 77.3,53.98 77.02,54.26 77.02,54.59 77.3,54.86 79.25,54.86 81.2,56.81 83.33,56.81 83.81,57.28 86.07,57.28 v6(86.12,57.33) 86.13,57.35 86.52,57.35 87.3,58.12 R267.1
DEVSLP1: length 8.7
  TOP w0.127: v4(80.99,53.04) 81.36,53.41 RP4.1 82.23,53.6 TP145.1
  IN1 w0.089: v4(80.99,53.04) 80.86,52.91 77.66,52.91 v5(77.45,53.12)
  IN4 w0.089: v2(77.11,53.47) 77.11,53.46 v5(77.45,53.12)
  BOTTOM w0.127: v2(77.11,53.47) 77.05,53.53 77.05,53.88 76.82,54.11 76.54,54.11 76.41,54.24 76.41,54.68 76.58,54.86 76.89,54.86 77.27,55.24 U16.L2
DEVSLP2: length 116.5
  TOP w0.127: v4(77.15,54.56) R68.1 78.31,55.62 79.33,56.65 v4(79.33,58.17) ; R474.1 160.78,39.06 v6(160.72,39.12) ; v4(87.11,58.3) 87.11,58.95 86.53,59.53 86.18,59.53 85.9,59.81 85.9,60.11 86.2,60.42 86.79,60.42 v4(86.8,60.41)
  IN1 w0.089: v6(160.72,39.12) 160.72,39.37 160.13,39.96 160.13,46.89 149.59,57.43 v5(149.59,60.23) ; v5(87.11,60.28) 86.98,60.41 v4(86.8,60.41) ; v4(77.15,54.56) v5(76.79,54.56) ; v4(87.11,58.3) 87.01,58.2 83.24,58.2 82.9,57.87 79.64,57.87 v4(79.33,58.17)
  IN3 w0.089: v5(76.79,54.56) 76.59,54.56 76.16,54.13 75.93,54.13 75.64,54.42 v2(75.38,54.42) ; v5(87.11,60.28) 87.11,60.1 87.94,59.26 88.91,59.26 90.54,60.89 93.46,60.89 93.63,60.71 93.63,59.77 94.5,58.91 97.39,58.91 97.98,58.32 109.1,58.32 111.11,56.32 121.6,56.32 125.89,60.61 130.52,60.61 131.43,59.69 144.28,59.69 144.49,59.9 149.26,59.9 v5(149.59,60.23)
  BOTTOM w0.127: CON1.44 160.24,40.05 160.72,39.58 v6(160.72,39.12)
DMIC_CLK: length 201.1
  IN1 w0.089: v5(76.46,64.44) 76.33,64.3 76.04,64.3 75.32,63.58 72.17,63.58 71.86,63.28 66.25,63.28 64.92,61.95 64.92,61.56 63.95,60.6 61.49,60.6 61.27,60.81 58,60.81 57.75,61.07 50.94,61.07 49.27,62.73 46.69,62.73 45.33,61.37 43.55,61.37 42.33,62.59 39.1,62.59 37.96,61.45 37.96,58.94 35.98,56.95 35.98,50.03 30.44,44.49 20.67,44.49 17.5,41.32 17.5,38.94 v6(17.14,38.58)
  IN4 w0.089: v2(179.96,47.96) 179.79,48.13 179.79,49.56 178.32,51.03 176.29,51.03 171,56.32 167.65,56.32 166.86,57.1 156.98,57.1 156.59,57.5 141.83,57.5 139.95,59.38 134.52,59.38 133.6,58.46 118.66,58.46 117.55,57.35 107.49,57.35 106.73,58.1 94.19,58.1 94.11,58.18 93.12,58.18 92.99,58.3 90.33,58.3 89.57,59.06 89.57,61.98 88.98,62.58 87.57,62.58 85.19,60.19 82.24,60.19 78.13,64.3 76.6,64.3 v5(76.46,64.44)
  BOTTOM w0.127: v6(17.14,38.58) 17.4,38.32 CN3.43 ; R309.2 181.1,49 181.1,48.73 180.78,48.42 179.92,48.42 179.79,48.28 179.79,48.13 v2(179.96,47.96)
DMIC_DATA: length 200
  IN1 w0.089: v6(18.21,38.58) 17.85,38.94 17.85,41.18 20.81,44.14 30.58,44.14 36.32,49.88 36.32,56.81 38.3,58.79 38.3,61.31 39.24,62.25 42.19,62.25 43.41,61.03 45.47,61.03 46.83,62.39 49.13,62.39 50.79,60.72 57.6,60.72 57.86,60.47 61.13,60.47 61.35,60.25 64.09,60.25 65.26,61.42 65.26,61.8 66.39,62.93 72.01,62.93 72.31,63.24 75.46,63.24 76.18,63.96 76.33,63.96 v5(76.46,63.83)
  IN4 w0.089: v5(76.46,63.83) 76.6,63.96 77.99,63.96 82.1,59.85 85.33,59.85 87.72,62.23 88.83,62.23 89.23,61.84 89.23,58.92 90.18,57.96 92.85,57.96 92.98,57.83 93.97,57.83 94.04,57.76 106.59,57.76 107.35,57 117.69,57 118.81,58.12 133.74,58.12 134.66,59.03 139.81,59.03 141.69,57.15 156.45,57.15 156.84,56.76 166.72,56.76 167.51,55.97 170.86,55.97 176.14,50.69 178.18,50.69 179.45,49.42 179.45,48.2 v2(179.21,47.96)
  BOTTOM w0.127: v2(179.21,47.96) 179.23,47.96 179.41,48.14 179.41,48.44 179.77,48.8 180.62,48.8 180.72,48.89 180.72,49 R308.2 ; v6(18.21,38.58) 17.9,38.27 CN3.44
DOCK_PSID: length 3.8
  TOP w0.127: v7(9.33,11.31) 9.24,11.4 v6(8.61,11.4) 8.47,11.26 FL1.1
  BOTTOM w0.127: CN7.3 v6(8.61,11.4)
DP_UTIL: length 5
  BOTTOM w0.127: R258.1 R259.1 52.03,64.62 v7(51.72,64.32) 51.72,62.69 52.14,62.27 U16.A43
DPWROK: length 101.8
  TOP w0.127: v9(138.37,62.44) 138.37,62.77 138.52,62.92 138.52,63.81 138.68,63.97 R20.1 139.02,64.75 v7(139.28,65) ; v9(74.13,33.35) R168.2
  IN1 w0.089: v9(137.3,37.37) 137.3,37.89 137.02,38.17 137.02,38.92 135.97,39.96 135.97,43.64 134.81,44.81 134.81,49.19 136.5,50.89 136.5,51.55 136.03,52.02 136.03,53.14 v9(136.15,53.27)
  IN2 w0.089: v9(74.13,33.35) 79.38,33.35 83.26,29.48 98.99,29.48 99.23,29.72 99.23,30.27 101.55,32.59 101.76,32.59 102.68,33.51 103.95,33.51 105.78,35.34 112.25,35.34 112.4,35.49 112.96,35.49 113.12,35.64 120.08,35.64 120.56,36.12 129.32,36.12 129.7,36.5 132.55,36.5 132.93,36.12 133.77,36.12 134.4,36.76 136.69,36.76 v9(137.3,37.37) ; v9(136.15,53.27) 136.15,54.21 136.1,54.27 136.1,55.11 136.69,55.71 136.69,56.16 136.81,56.29 136.81,57.43 137.22,57.84 137.22,58.2 137.14,58.27 137.14,59.31 136.64,59.82 136.64,60.66 136.76,60.79 136.76,62.06 137.14,62.44 v9(138.37,62.44)
DPWROK_R: length 8.7
  TOP w0.127: R167.1 R168.1 R163.1 74.5,36.14 v7(75.4,37.04) 75.73,37.37 v6(76.16,37.37)
  BOTTOM w0.089: U16.AV5 75.1,40.14 75.1,38.63 76.13,37.6 76.13,37.39 v6(76.16,37.37)
DQA_ZQ0: length 4.5
  BOTTOM w0.127: U18.L8 14.81,15.37 12.48,15.37 v7(12.02,15.83) 12.01,15.85 R393.1
DQA_ZQ1: length 3.4
  TOP w0.127: v7(11.39,14.3) 11.41,14.3 11.77,14.67 R242.1 13.08,14.67 v6(13.09,14.66)
  BOTTOM w0.127: U18.L9 14.29,15.09 13.52,15.09 v6(13.09,14.66)
DQA_ZQ2: length 7.5
  BOTTOM w0.127: R398.1 24.6,8.89 v7(24.93,9.22) 25.97,10.27 25.97,14.36 26.39,14.77 U19.L8
DQA_ZQ3: length 9
  TOP w0.127: v6(23.35,8.89) 23.35,9.25 22.87,9.73 R249.1
  BOTTOM w0.127: v6(23.35,8.89) 23.35,9.55 v7(23.28,9.63) 24.27,10.62 24.27,14.1 25.14,14.97 U19.L9
DQA_ZQ4: length 10
  BOTTOM w0.127: U20.L8 37.16,15.38 35.69,15.38 34.58,14.27 34.58,9.65 v7(34.1,9.17) 34.12,9.15 R403.1
DQA_ZQ5: length 8.6
  BOTTOM w0.127: R402.1 35.29,9.1 v7(35.37,9.17) 34.86,9.68 34.86,14.13 35.82,15.09 36.64,15.09 U20.L9
DQA_ZQ6: length 7.7
  BOTTOM w0.127: v7(47.2,8.49) 47.22,8.47 R396.1 48.09,9.99 48.32,10.22 48.32,14.28 48.74,14.7 U21.L8
DQA_ZQ7: length 8.1
  TOP w0.127: v6(45.76,8.89) 45.69,8.96 R248.1
  BOTTOM w0.127: U21.L9 47.49,14.97 46.62,14.1 46.62,10.65 45.76,9.78 v6(45.76,8.89)
DQB_ZQ0: length 9.4
  BOTTOM w0.127: v7(59.01,8.34) 59.01,8.34 R397.1 58.13,10.16 57.03,11.25 57.03,14.05 57.57,14.58 58.64,14.58 U22.L8
DQB_ZQ1: length 3.3
  TOP w0.127: R237.1 v7(58.5,16.97)
  TOP w0.254: v6(57.41,15.57) 57.92,16.08 R237.1
  BOTTOM w0.127: U22.L9 57.94,14.97 57.41,15.5 v6(57.41,15.57)
DQB_ZQ2: length 7.1
  BOTTOM w0.127: U23.L8 69.78,14.55 v7(69.78,9.25) 69.78,8.57 R399.1
DQB_ZQ3: length 8.8
  TOP w0.127: v6(67.17,8.89) 67.5,9.22 R251.1
  BOTTOM w0.127: U23.L9 68.95,14.97 68.08,14.1 68.08,10.65 67.17,9.73 v6(67.17,8.89)
DQB_ZQ4: length 9.6
  BOTTOM w0.127: R400.1 80.35,9.2 v7(80.38,9.22) 80.38,9.25 81.11,9.99 82.38,9.99 82.89,10.49 82.89,14.18 82.51,14.56 82.05,14.56 81.64,14.97 U24.L8
DQB_ZQ5: length 13.2
  TOP w0.127: v6(73.19,8.74) 73.19,8.25 R252.1
  BOTTOM w0.127: v6(73.19,8.74) 73.19,9.02 73.62,9.45 77.4,9.45 79.46,11.51 79.46,14.41 80.03,14.97 U24.L9
DQB_ZQ6: length 7.2
  BOTTOM w0.127: U25.L8 92.55,14.97 92.14,14.56 92.14,9.89 v7(92.8,9.22) R401.1
DQB_ZQ7: length 8.5
  TOP w0.127: v6(89.52,8.89) 89.49,8.92 R250.1
  BOTTOM w0.127: U25.L9 90.85,14.97 90.43,14.56 90.43,10.65 89.52,9.73 v6(89.52,8.89)
DSP_BITCLK: length 8.2
  TOP w0.127: v4(100.92,31.4) 100.92,31.58 100.92,31.59 R174.2 100.43,32.39 v7(99.88,32.39) 99.76,32.51 EC6.1
  IN1 w0.089: v4(100.92,31.4) 100.92,30.46 101.38,30 101.38,27.92 101.99,27.31 101.99,26.45 v4(102.07,26.37)
DSP_BITCLK_R: length 2.3
  TOP w0.127: U10.23 102.89,32.86 102.65,32.62 102.65,32.16 102.39,31.91 R174.1
DSP_RST#: length 13.2
  TOP w0.127: v4(101.66,24.52) 101.84,24.34 R209.1 ; v4(101.43,32.41) 101.43,32.59 101.38,32.64 101.38,33.68 v6(101.89,34.19) 101.89,34.4 102.85,35.36 U10.18
  IN1 w0.089: v4(101.66,24.52) 101.79,24.64 101.79,25.48 102.35,26.04 102.35,27.59 101.76,28.17 101.76,30.18 101.43,30.51 v4(101.43,32.41)
DSP_SDIN0: length 9.7
  TOP w0.127: v4(102.19,32.41) 102.19,32.65 102.28,32.74 102.28,33.37 102.77,33.86 U10.21
  IN1 w0.089: v4(102.19,25.35) 102.69,25.85 102.69,31.92 v4(102.19,32.41)
DSP_SDOUT: length 6.4
  TOP w0.127: R194.1 102.19,27.65 102.34,27.81 102.94,27.81 103.05,27.92 v4(103.54,27.92) ; U10.24 v4(103.47,32.36)
  IN1 w0.089: v4(103.54,27.92) 103.36,28.1 103.36,30.61 103.47,30.72 v4(103.47,32.36)
DSP_SYNC: length 9
  TOP w0.127: U10.19 102.91,34.86 102.65,34.6 102.65,34.27 101.86,33.49 101.86,32.95 v6(101.84,32.92) 101.81,32.9 v4(101.81,32.41)
  IN1 w0.089: v4(101.81,32.41) 101.81,32.26 101.79,32.24 101.79,32.14 101.85,32.07 102.03,32.07 102.19,31.91 102.19,31.78 102.11,31.69 101.88,31.69 101.79,31.6 101.79,31.4 101.86,31.32 102.19,31.32 102.27,31.25 102.27,31.04 102.21,30.98 101.9,30.98 101.81,30.89 101.81,30.71 101.9,30.62 102.13,30.62 102.19,30.56 v4(102.19,28.4)
DSWVRMEN: length 6.9
  BOTTOM w0.089: U16.AW7 73.6,39.45 73.6,38.55 73.72,38.43
  BOTTOM w0.102: 74.28,37.34 74.28,37.88 73.72,38.43
  BOTTOM w0.127: R362.2 76.41,34.45 v7(75.7,35.16) 75.7,35.46 74.28,36.89 74.28,37.34
EAPD#: length 157.9
  IN1 w0.089: v6(11.97,34.77) 11.97,34.47 12.25,34.19 13.95,34.19 14.72,34.96 14.72,35.4 16.39,37.06 18.81,37.06 20.05,38.31 20.05,39.83 22.43,42.21 30.08,42.21 37.27,49.41 37.27,56.14 38.85,57.71 42.53,57.71 44.09,59.27 57.49,59.27 57.67,59.08 65.01,59.08 66.66,60.74 68.79,60.74 69.94,61.88 72.4,61.88 72.78,62.26 74.33,62.26 74.43,62.36 76.06,62.36 76.73,61.69 76.73,60.35 79.56,57.52 82.83,57.52 83.3,57.99 90.74,57.99 91.25,58.5 103.85,58.5 104.28,58.07 v9(104.91,58.07) ; v4(140.51,54.48) v9(140.51,54.07)
  IN2 w0.089: v9(104.91,58.07) 106.61,56.37 113.57,56.37 115.53,54.41 123.4,54.41 124.24,53.57 126.25,53.57 129.47,50.35 135.19,50.35 135.72,50.88 137.09,50.88 137.58,50.4 139.25,50.4 140.34,51.49 140.34,53.91 v9(140.51,54.07)
  BOTTOM w0.127: CN3.22 12.4,33.94 11.97,34.37 v6(11.97,34.77)
EC_SPI_CS#: length 42.4
  TOP w0.127: v4(138.41,61.68) 138.01,61.27 U4.A7
  IN1 w0.089: v4(138.41,61.68) 138.1,61.99 138.1,63.87 137.68,64.29 137.2,64.29 136.41,65.08 132.39,65.08 131.74,64.43 131.04,64.43 129.66,63.06 126.25,63.06 124.64,61.44 124.33,61.44 120.93,58.04 119.32,58.04 116.88,55.61 115.17,55.61 115,55.43 111.78,55.43 v5(110.7,54.35)
  IN4 w0.102: v2(110.37,54.35) v5(110.7,54.35)
  BOTTOM w0.127: RP28.2 105.81,55.13 106.13,55.45 109.56,55.45 v7(109.71,55.3) 110.37,54.64 v2(110.37,54.35)
EC_SPI_DIN: length 45.6
  TOP w0.127: R7.1 138.39,65.18 137.3,64.09 v4(137.3,63.33)
  IN1 w0.089: v5(112.25,54.35) 112.61,54.72 115.3,54.72 115.48,54.89 117.23,54.89 119.67,57.33 121.24,57.33 124.65,60.74 125.07,60.74 126.7,62.37 129.99,62.37 131.37,63.75 132.03,63.75 132.67,64.39 135.73,64.39 136.79,63.33 v4(137.3,63.33) 137.41,63.21 137.41,59.57 v4(137.51,59.48)
  IN4 w0.102: v5(112.25,54.35) 112.23,54.34 v2(111.91,54.34)
  BOTTOM w0.127: v2(111.91,54.34) 111.91,54.33 111.9,54.34 111.9,54.77 110.45,56.21 105.5,56.21 v6(105.29,56.01) 104.74,55.46 RP28.6
EC_SPI_DO: length 44.5
  TOP w0.127: v4(137.8,62.31) 137.88,62.39 R19.1 137.69,63.19 137.32,62.82 137.32,61.42 137.51,61.24 U4.A6
  IN1 w0.089: v4(137.8,62.31) 137.75,62.36 137.75,63.38 137.2,63.94 136.69,63.94 135.89,64.74 132.53,64.74 131.88,64.09 131.2,64.09 129.83,62.72 126.54,62.72 124.91,61.09 124.47,61.09 121.06,57.69 119.52,57.69 117.08,55.25 115.33,55.25 115.15,55.07 112.2,55.07 111.55,54.43 111.47,54.35 111.47,54.34 v5(111.47,54.33)
  IN4 w0.102: v2(111.13,54.35) 111.46,54.35 v5(111.47,54.33)
  BOTTOM w0.127: RP28.4 105.24,55.32 105.75,55.83 110.07,55.83 v7(110.98,54.92) 111.13,54.77 v2(111.13,54.35)
EC_SPI_SLK: length 43.1
  IN1 w0.089: v5(113.03,54.35) 115.44,54.35 115.63,54.54 117.41,54.54 119.8,56.93 121.4,56.93 124.86,60.38 125.26,60.38 126.65,61.78 128.33,61.78 128.64,62.08 130.21,62.08 131.45,63.33 132.17,63.33 132.89,64.05 135.57,64.05 136.68,62.95 136.69,62.95 137.07,62.57 137.07,60.66 136.74,60.33 136.74,59.9 137.01,59.63 v4(137.01,59.48)
  IN4 w0.102: v2(112.68,54.35) v5(113.03,54.35)
  BOTTOM w0.127: v2(112.68,54.35) 112.4,54.63 112.4,55.02 v7(111.26,56.16) 110.83,56.6 105.24,56.6 104.16,55.52 RP28.8
EC_VCCST_PWRGD: length 78.9
  TOP w0.127: v4(87.39,53.5) 87.39,53.37 86.93,52.91 R406.1 ; v4(140.55,62.59) 141.03,62.59 141.56,63.12 141.56,65.21 v6(141.64,65.28) 142.13,65.28 R404.1 142.77,65.6 142.96,65.79 142.96,66.59 142.66,66.89 142.26,66.89 141.68,67.47 125.61,67.47 123.56,65.41 115.35,65.41 114.31,66.45 111.82,66.45 108.79,63.42 108.79,58.39 106.03,55.63 v4(102.73,55.63)
  IN1 w0.089: v4(138.51,59.48) 138.51,59.89 139.25,60.63 139.25,61.42 139.41,61.57 139.58,61.57 140.55,62.54 v4(140.55,62.59) ; v4(87.39,53.5) 87.53,53.35 88.27,53.35 88.48,53.14 89.89,53.14 90.55,53.81 90.55,54.5 90.64,54.59 90.64,54.59 92.19,56.14 102.22,56.14 v4(102.73,55.63)
EDP_AUXN: length 157.5
  IN4 w0.127: v2(50.76,61.71) 50.8,61.68 50.91,61.68 51.05,61.82 51.05,62.4 53.15,64.5 57.87,64.5 58.53,63.83 63.64,63.83 63.99,64.19 70.92,64.19 73.02,66.29 77.47,66.29 77.77,65.98 80.85,65.98 81.59,66.73 87.97,66.73 94.09,60.61 94.09,60.05 94.26,59.89 105.86,59.89 107.6,61.62 108.65,61.62 110.79,63.77 117.83,63.77 121.27,60.33 125.66,60.33 126.4,61.07 144.49,61.07 145.12,60.43 148.02,60.43 148.82,59.62 156.96,59.62 157.66,58.92 167.51,58.92 168.34,58.09 173.6,58.09 178.32,53.37 179.74,53.37 185.61,47.5 185.61,46.51 185.68,46.44 v2(185.81,46.44)
  BOTTOM w0.14: EL6.4 186.51,45.26 186.67,45.09 186.67,45.01 v7(186.17,44.51) 186.67,44 186.67,43.86 186.53,43.72 186.05,43.72 185.56,44.22 185.56,46.41 185.63,46.49 185.76,46.49 v2(185.81,46.44)
EDP_AUXN_C: length 4.6
  BOTTOM w0.14: C252.1 186.65,49.23 186.65,49.5 R305.1 186.63,50.47 186.63,50.75 186.97,51.1 187.33,51.1 187.47,51.24 187.47,51.4 187.35,51.52 J1.31
EDP_AUXN_R: length 1.5
  BOTTOM w0.14: EL6.3 186.51,47.26 186.65,47.41 186.65,47.7 C252.2
EDP_AUXP: length 157.5
  IN4 w0.127: v2(50.76,61.06) 51.08,61.38 51.38,61.68 51.38,62.27 53.29,64.17 57.73,64.17 58.4,63.5 63.77,63.5 64.13,63.86 71.06,63.86 73.16,65.96 77.33,65.96 77.64,65.65 80.98,65.65 81.73,66.4 87.83,66.4 93.76,60.47 93.76,59.91 94.12,59.55 106,59.55 107.74,61.29 108.78,61.29 110.93,63.44 117.69,63.44 121.13,60 125.8,60 126.54,60.74 144.35,60.74 144.98,60.1 147.88,60.1 148.69,59.29 156.82,59.29 157.53,58.59 167.37,58.59 168.2,57.76 173.46,57.76 178.18,53.04 179.6,53.04 185.28,47.37 185.28,46.49 v2(185.2,46.41)
  BOTTOM w0.14: v2(185.2,46.41) 185.29,46.32 185.29,44.11 185.94,43.46 186.64,43.46 186.94,43.75 186.94,44 v7(187.44,44.51) 186.94,45.01 186.94,45.11 187.06,45.23 EL6.1
EDP_AUXP_C: length 4.6
  BOTTOM w0.14: C253.1 186.91,49.23 186.91,49.5 R306.1 186.9,50.5 186.9,50.64 187.08,50.83 187.44,50.83 187.74,51.13 187.74,51.4 187.85,51.51 J1.30
EDP_AUXP_R: length 1.5
  BOTTOM w0.14: C253.2 186.91,47.7 186.91,47.41 187.06,47.26 EL6.2
EDP_COMP: length 2.1
  TOP w0.508: v6(66.38,58.17) 66.37,58.18 R40.1 66.37,59.38 v6(66.58,59.59)
  BOTTOM w0.305: U16.D20 66.92,59.93 v6(66.58,59.59)
EDP_HPD: length 130.6
  TOP w0.127: v4(81.74,59.52) 81.74,59.69 82.18,60.13 84.59,60.13 84.87,60.41 85.18,60.41 85.83,61.06 85.85,61.08 86.32,61.55 86.34,61.57 87.08,62.31 87.08,64.6 87.84,65.36 v7(87.84,66.17) 87.89,66.12 92.19,66.12 93,66.93 v4(93,66.93)
  IN1 w0.089: v5(92.44,67.58) 92.44,67.49 v4(93,66.93) ; v4(81.74,59.52) 81.74,59.64 v5(81.53,59.85)
  IN4 w0.089: v2(74.65,59.93) 74.8,59.77 75.38,59.77 76.58,60.96 78.06,60.96 78.72,61.62 79.83,61.62 81.53,59.93 v5(81.53,59.85) ; v5(92.44,67.58) 92.53,67.67 108.54,67.67 108.72,67.49 110.51,67.49 112.75,65.25 120.08,65.25 120.51,64.83 127.95,64.83 129.88,66.76 143.75,66.76 147.76,62.74 150.17,62.74 150.58,63.15 167.8,63.15 169.2,61.75 169.2,59.92 169.65,59.47 174.55,59.47 176.92,57.1 179.41,57.1 180.49,56.02 184.63,56.02 v2(185.58,55.07)
  BOTTOM w0.127: J1.33 186.35,52.8 185.96,53.19 185.96,54.69 v2(185.58,55.07)
EDP_TXN0: length 161.3
  IN4 w0.127: v2(189.61,44.8) 189.76,44.8 189.89,44.92 189.89,44.99 189.72,45.17 188.69,45.17 188.23,44.71 185.57,44.71 178.21,52.07 177.65,52.07 175.78,53.94 175.61,53.94 175.11,53.45 174.68,53.45 173.48,54.64 173.48,55.08 173.98,55.57 173.98,55.74 172.81,56.91 167.86,56.91 167.08,57.69 157.13,57.69 156.37,58.46 145.98,58.46 145.31,59.12 144.23,59.12 143.47,59.89 133.94,59.89 133.01,58.96 118.44,58.96 117.33,57.84 115.87,57.84 115.75,57.73 114.19,57.73 114.07,57.84 107.7,57.84 106.82,58.72 93.76,58.72 93.69,58.79 90.54,58.79 90.08,59.25 90.08,62.21 89.19,63.1 87.38,63.1 84.96,60.68 82.45,60.68 78.31,64.81 77.2,64.81 76.9,65.12 74.81,65.12 72.61,62.92 57.89,62.92 57.51,63.3 53.66,63.3 52.14,61.78 52.14,61.43 51.25,60.54 51.25,60.34 51.01,60.1 50.63,60.1 50.56,60.18 50.56,60.3 50.67,60.41 v2(50.76,60.41)
  BOTTOM w0.14: v2(189.61,44.8) 189.76,44.8 189.85,44.89 189.85,44.99 v7(189.35,45.5) 189.85,46 189.85,46.11 189.68,46.27 EL3.4
EDP_TXN0_C: length 3
  BOTTOM w0.14: J1.28 188.85,51.52 188.97,51.4 188.97,51.16 189.26,50.88 189.46,50.88 189.69,50.64 189.69,50.24 C248.1
EDP_TXN0_R: length 1.5
  BOTTOM w0.14: C248.2 189.76,48.65 189.76,48.36 189.68,48.28 EL3.3
EDP_TXN1: length 161.1
  IN4 w0.127: v2(49.64,61.71) 49.64,61.63 49.72,61.55 49.89,61.55 49.96,61.61 49.96,62.68 52.62,65.34 58.12,65.34 59.03,64.43 63.22,64.43 63.98,65.19 70.33,65.19 72.61,67.48 88.93,67.48 89.94,66.46 93.29,66.46 94.03,67.2 102,67.2 102.19,67.39 107.71,67.39 110.36,64.73 118.14,64.73 121.68,61.19 124.62,61.19 125.94,62.51 128.43,62.51 129.88,63.96 139.81,63.96 140.42,63.35 146.11,63.35 147.66,61.8 156.18,61.8 158.1,59.89 167.88,59.89 168.82,58.95 174.01,58.95 176.78,56.18 179.04,56.18 181.19,54.03 181.19,53.69 184.96,49.92 187.83,49.92 190.87,46.88 190.87,45.68 191.36,45.18 191.68,45.18 191.76,45.26 191.76,45.49 191.69,45.56 v2(191.52,45.56)
  BOTTOM w0.14: EL4.4 191.59,46.11 191.82,45.88 191.82,45.69 191.69,45.56 v2(191.52,45.56)
EDP_TXN1_C: length 3.4
  BOTTOM w0.14: J1.25 190.35,51.52 190.47,51.4 190.47,51.16 190.76,50.88 191.25,50.88 191.72,50.41 191.72,50.24 C250.1
EDP_TXN1_R: length 1.5
  BOTTOM w0.14: EL4.3 191.59,48.28 191.73,48.42 191.73,48.72 C250.2
EDP_TXP0: length 161.3
  IN4 w0.127: v2(50.2,60.74) 50.51,60.74 50.53,60.76 51.01,60.76 51.81,61.56 51.81,61.92 53.52,63.63 57.65,63.63 58.03,63.25 72.47,63.25 74.67,65.45 77.04,65.45 77.34,65.14 78.45,65.14 82.58,61.01 84.82,61.01 87.24,63.43 89.33,63.43 90.41,62.35 90.41,59.39 90.68,59.12 93.82,59.12 93.9,59.05 106.96,59.05 107.83,58.17 114.21,58.17 114.32,58.06 115.62,58.06 115.73,58.17 117.19,58.17 118.31,59.29 132.88,59.29 133.8,60.22 143.61,60.22 144.37,59.45 145.45,59.45 146.11,58.79 156.5,58.79 157.27,58.02 167.22,58.02 168,57.24 172.95,57.24 174.31,55.88 174.31,55.43 173.81,54.94 173.81,54.78 174.81,53.78 174.97,53.78 175.47,54.27 175.91,54.27 177.78,52.4 178.34,52.4 185.71,45.04 188.09,45.04 188.55,45.5 189.85,45.5 190.22,45.13 190.22,44.89 v2(190.3,44.8)
  BOTTOM w0.14: EL3.1 190.23,46.21 190.12,46.09 190.12,46 v7(190.62,45.5) 190.12,45 190.12,44.9 190.21,44.8 v2(190.3,44.8)
EDP_TXP0_C: length 3
  BOTTOM w0.14: J1.27 189.35,51.51 189.24,51.4 189.24,51.27 189.37,51.14 189.57,51.14 189.96,50.75 189.96,50.25 C249.1
EDP_TXP0_R: length 1.5
  BOTTOM w0.14: C249.2 190.03,48.78 190.03,48.48 190.23,48.28 EL3.2
EDP_TXP1: length 161.2
  IN4 w0.127: v2(192.21,45.56) 192.09,45.44 192.09,45.12 191.82,44.85 191.23,44.85 190.54,45.54 190.54,46.74 187.69,49.59 184.83,49.59 180.86,53.55 180.86,53.89 178.9,55.85 176.64,55.85 173.87,58.62 168.68,58.62 167.74,59.55 157.96,59.55 156.04,61.47 147.52,61.47 145.97,63.02 140.28,63.02 139.67,63.63 130.02,63.63 128.57,62.18 126.08,62.18 124.76,60.86 121.54,60.86 118,64.4 110.23,64.4 107.57,67.06 102.33,67.06 102.14,66.87 94.16,66.87 93.43,66.13 89.8,66.13 88.79,67.15 72.75,67.15 70.46,64.86 64.12,64.86 63.35,64.1 58.89,64.1 57.98,65.01 52.75,65.01 50.29,62.54 50.29,61.48 50.03,61.22 49.79,61.22 v2(49.64,61.06)
  BOTTOM w0.14: EL4.1 192.14,46.11 192.08,46.06 192.08,45.69 v2(192.21,45.56)
EDP_TXP1_C: length 3.4
  BOTTOM w0.14: C251.1 191.99,50.25 191.99,50.52 191.37,51.14 190.87,51.14 190.74,51.27 190.74,51.4 190.85,51.51 J1.24
EDP_TXP1_R: length 1.5
  BOTTOM w0.14: EL4.2 192.14,48.28 191.99,48.42 191.99,48.72 C251.2
EN_LCDVCC: length 5.8
  TOP w0.127: U5.3 187.22,54.99 187.55,54.66 R74.1 188.12,54.18 188.5,54.56 D9.3 189.34,56.6 v7(189.52,56.77)
ENVDD: length 144.2
  TOP w0.127: D9.1 191.35,55.25 191.35,60.93 v6(189.44,62.83)
  IN1 w0.089: v5(73.88,60.52) 74.15,60.25 75.68,60.25 75.85,60.08 76.2,60.08 77.4,58.88 79.54,56.74 83.08,56.74 83.68,57.33 91.16,57.33 91.55,57.73 103.06,57.73 103.53,57.26 109.71,57.26 110.88,58.42 112.13,58.42 113.24,57.31 115.81,57.31 116.06,57.56 116.32,57.56 118.7,59.95 118.7,60.91 122.39,64.6 v9(123.02,64.6)
  IN2 w0.089: v6(189.44,62.83) 189.85,63.24 189.85,64.75 188.63,65.97 178.44,65.97 176.8,67.62 167.09,67.62 164.56,65.09 159.07,65.09 156.82,67.33 v6(154.12,67.33) 152.29,67.33 152.11,67.34 151.72,67.73 138.52,67.73 138.29,67.49 127.47,67.49 126.69,66.72 125.02,66.72 123.02,64.72 v9(123.02,64.6)
  IN4 w0.089: v2(74.24,60.52) v5(73.88,60.52)
  BOTTOM w0.127: R257.1 151.33,66.62 v7(151.7,66.98) 152.05,67.33 v6(154.12,67.33) ; PR162.1 188.05,62.56 188.3,62.82 189.43,62.82 v6(189.44,62.83)
FAN_PWM: length 152.1
  IN1 w0.089: v9(105.99,57.56) 103.89,57.56 103.54,57.92 91.47,57.92 91.09,57.54 83.44,57.54 82.91,57 79.54,57 76.35,60.2 76.35,60.35 76.35,61.08 75.93,61.5 73.51,61.5 73.38,61.63 73.01,61.63 72.72,61.34 72.51,61.34 72.44,61.27 70.22,61.27 67.57,58.63 57.44,58.63 57.18,58.88 44.24,58.88 42.67,57.31 39.36,57.31 37.88,55.83 37.88,49.2 30.5,41.81 22.78,41.81 20.83,39.85 20.83,37.76 19.31,36.25 17.99,36.25 17.51,35.77 17.51,34.27 v6(15.07,31.83) ; v9(131.66,52.05) 131.73,52.05 133.33,50.45 135.77,50.45 136.31,50.99 136.31,51.46 135.82,51.95 135.82,53.34 136.28,53.8 136.84,53.8 137.51,54.47 v4(137.51,54.48)
  IN2 w0.089: v9(131.66,52.05) 131.56,52.15 130.64,52.15 129.68,53.12 128.13,53.12 126.48,54.77 115.53,54.77 113.43,56.86 106.69,56.86 v9(105.99,57.56)
  BOTTOM w0.127: v6(15.07,31.83) 15.4,32.16 CN3.16
FAN_PWR_EN_R: length 4.6
  TOP w0.127: v7(167.42,12.07) 167.43,12.08 PR143.2 PR144.1 169.48,13.01 170.14,13.67 PU16.3
FAN_TACH: length 157.6
  TOP w0.127: v6(12.63,34.77) 12.63,33.7 v7(12.48,33.56)
  IN1 w0.089: v9(104.35,58.68) 104.1,58.93 87.62,58.93 87.22,59.34 82.39,59.34 82.11,59.05 80.81,59.05 79.44,60.43 78.94,60.43 76.6,62.77 74.28,62.77 74.18,62.67 72.43,62.67 72.04,62.29 69.66,62.29 68.56,61.19 65.85,61.19 64.32,59.67 43.95,59.67 42.38,58.1 38.47,58.1 36.89,56.52 36.89,49.66 29.85,42.62 22.25,42.62 19.62,39.98 19.62,38.43 18.65,37.47 15.05,37.47 13.29,35.72 13.29,35.44 v6(12.63,34.77) ; v9(140.7,53.4) 140.68,53.4 140.01,54.06 v4(140.01,54.48)
  IN2 w0.089: v9(104.35,58.68) 104.35,58.23 106.65,55.94 113.45,55.94 115.18,54.2 123.18,54.2 124.09,53.29 126.17,53.29 129.31,50.16 135.35,50.16 135.85,50.65 136.92,50.65 137.4,50.17 139.3,50.17 140.7,51.57 v9(140.7,53.4)
  BOTTOM w0.127: v6(12.63,34.77) 12.63,34.44 12.9,34.17 CN3.21
GPIO14: length 3
  TOP w0.127: TP31.1 76.29,45.92 v4(75.65,46.55)
  IN1 w0.089: v4(75.65,46.55) 76.3,45.9 v5(76.41,45.9)
  IN4 w0.089: v5(76.41,45.9) 76.27,46.05 v2(76.27,46.21)
  BOTTOM w0.127: U16.AH4 v2(76.27,46.21)
GPIO15: length 7.1
  TOP w0.127: v4(79.59,47.99) 79.59,48.2 R108.1
  IN1 w0.089: v4(79.59,47.99) 79.82,47.75 v5(79.84,47.75)
  IN3 w0.089: v2(74.73,48.71) 75.22,49.2 75.44,49.2 75.77,49.53 76.36,49.53 77.25,48.65 78.95,48.65 v5(79.84,47.75)
GPIO24: length 6
  TOP w0.127: v4(78.11,48.21) 78.11,48.59 v7(78.85,49.33) 79,49.48 R100.1
  IN1 w0.089: v5(78.04,47.75) 78.04,48.14 v4(78.11,48.21)
  IN3 w0.089: v5(78.04,47.75) 77.55,48.24 76.77,48.24 76.3,48.71 v2(75.38,48.71)
GPIO25: length 3.2
  TOP w0.127: R476.1 78.56,43.14 78.11,43.59 v4(76.51,43.59)
  IN1 w0.089: v4(76.51,43.59) 76.48,43.59 76.46,43.61 76.46,43.9 76.49,43.92 v5(76.49,43.95)
  IN4 w0.089: v2(76.06,44) 76.44,44 v5(76.49,43.95)
GPIO26: length 9.5
  BOTTOM w0.127: U16.AN3 77.02,42.91 79.44,42.91 81.59,45.06 84.62,45.06 R329.1
GPIO28: length 3.8
  TOP w0.127: TP23.1 77.25,48.47 v4(76.42,48.47)
  IN1 w0.089: v5(74.29,48.71) 74.53,48.47 v4(76.42,48.47)
  IN4 w0.089: v5(74.29,48.71) v2(73.96,48.71)
  BOTTOM w0.127: U16.AD7 v2(73.96,48.71)
GPIO35: length 6
  BOTTOM w0.127: U16.U1 78.12,52.35 78.65,52.35 80.81,54.51 TP80.1 82.15,54.51 82.56,54.11 R287.1
GPIO36: length 4.5
  TOP w0.127: v4(77.66,50.58) 77.73,50.5 R97.1 77.83,49.81 TP22.1
  IN1 w0.089: v5(77.36,50.73) 77.51,50.58 v4(77.66,50.58)
  IN4 w0.089: v2(74.73,51.57) 74.81,51.57 75.62,50.75 77.33,50.75 v5(77.36,50.73)
GPIO37: length 5.4
  BOTTOM w0.127: R301.1 82.76,50.63 82.26,50.12 TP94.1 80.37,49.38 78.14,49.38 U16.AC1
GPIO44: length 2.6
  TOP w0.127: R127.1 74.64,45.17 74.84,45.37 v4(74.84,45.72)
  IN1 w0.089: v5(75.6,45.9) 75.02,45.9 v4(74.84,45.72)
  IN4 w0.089: v5(75.6,45.9) 75.68,45.83 v2(75.93,45.83)
  BOTTOM w0.127: v2(75.93,45.83) 76.06,45.69 U16.AK4
GPIO51: length 15.2
  TOP w0.127: v4(84.57,53.04) 84.72,53.19 84.72,53.89 R84.1 85.28,55.43 v7(85.23,55.48)
  IN1 w0.089: v5(84.56,52.68) 84.56,53.01 84.57,53.01 v4(84.57,53.04)
  IN3 w0.089: v2(75.38,53.47) 75.63,53.47 75.91,53.19 75.91,52.51 75.96,52.46 75.96,51.85 76.18,51.62 77.4,51.62 78.06,52.28 79.23,52.28 80.38,51.13 81.24,51.13 82.04,51.93 83.81,51.93 v5(84.56,52.68)
GPIO52: length 12.8
  BOTTOM w0.089: U16.L1 78.39,55.24
  BOTTOM w0.127: 78.39,55.24 79.21,55.24 81.03,57.06 83.23,57.06 83.7,57.54 85.58,57.54 86.08,58.03 86.08,58.79 86.85,59.56 86.85,59.64 v7(87.23,60.02) 87.39,60.02 87.58,59.83 R269.1
GPIO53: length 16.5
  IN3 w0.089: v2(84.19,56.21) 83.47,55.5 80.22,55.5 79.99,55.73 78.19,55.73 77.38,54.92 77.38,54.36 76.87,53.85 76.46,53.85 76.27,53.66 75.57,53.66 75.5,53.74 75.5,53.74 75.38,53.85 74.15,53.85 73.77,54.23 73.77,54.56 74.1,54.89 75.38,54.89 75.91,55.42 v2(75.91,55.55)
  BOTTOM w0.127: v2(75.91,55.55) 75.91,55.36 U16.L4 ; R276.1 84.36,56.39 v2(84.19,56.21)
GPIO54: length 9.3
  BOTTOM w0.089: 78.39,55.53 77.15,55.53 77.06,55.44
  BOTTOM w0.127: 78.39,55.53 78.43,55.53 78.58,55.68 79.27,55.68 81.15,57.56 v6(81.77,57.56) 83.22,57.56 83.45,57.79 84.33,57.79 R277.1 ; U16.L3 76.83,55.2 77.06,55.44
GPIO58: length 24.5
  TOP w0.127: R124.1 91.9,44.92 92.21,44.61 v7(92.44,44.61) 92.62,44.78 v4(93.46,44.78)
  IN1 w0.089: v5(94.75,44.39) 94.56,44.58 93.66,44.58 v4(93.46,44.78)
  IN3 w0.089: v5(94.75,44.39) 94.75,44.34 94.51,44.1 93.63,44.1 92.97,44.76 83.37,44.76 81.82,43.21 77.81,43.21 76.03,44.99 v2(75.99,44.99)
  BOTTOM w0.127: v2(75.99,44.99) 75.99,44.79 U16.AL4
GPIO60: length 9.3
  BOTTOM w0.127: R325.1 84.73,46.64 84.14,46.05 82.51,46.05 82.01,45.55 80.91,45.55 79.84,44.49 78.74,44.49 78.1,45.13 77.94,45.13 77.82,45.24 77.58,45.24 77.4,45.06 77.4,44.79 U16.AL2
GPIO70: length 2.6
  TOP w0.127: R34.1 76.18,60.15 v4(75.78,60.56) 75.78,61.12 v7(75.75,61.14)
  IN1 w0.089: v5(75.78,61.02) v4(75.78,60.56)
  IN4 w0.089: v2(75.6,60.74) 75.78,60.91 v5(75.78,61.02)
  BOTTOM w0.127: U16.C4 75.89,60.44 v2(75.6,60.74)
GPIO73: length 20.3
  TOP w0.127: RP7.1 88.48,43.43 88.43,43.39 TP34.1 88.02,42.84 v4(88.13,42.72)
  IN1 w0.089: v5(88.73,42.53) 88.54,42.72 v4(88.13,42.72)
  IN3 w0.089: v5(88.73,42.53) 88.73,42.47 88.73,42.47 88.73,41.69 85.2,38.16 81.26,38.16 80.6,38.82 v2(79.33,38.82)
  BOTTOM w0.089: U16.AU4 76.37,40.74 76.37,39.31 76.41,39.27 76.41,38.82
  BOTTOM w0.127: 76.41,38.82 77.1,38.13 78.78,38.13 79.33,38.69 v2(79.33,38.82)
GPIO78: length 3.9
  IN1 w0.089: v4(78.31,53.55) 76.06,53.55 v5(75.55,53.04)
  IN4 w0.089: v5(75.55,53.04) 75.83,53.32 v2(75.83,53.37)
  BOTTOM w0.127: v2(75.83,53.37) 75.88,53.37 76.06,53.55 U16.P4
GPIO79: length 9.2
  TOP w0.127: v4(82.3,55.8) 82.3,55.24 v7(82.26,55.2) 81.63,55.2 R65.1
  IN1 w0.089: v4(82.3,55.8) 82.15,55.95 v5(82.15,56.18)
  IN3 w0.089: v5(82.15,56.18) 82.06,56.27 77.91,56.27 v2(76.06,54.42)
  BOTTOM w0.127: U16.N4 v2(76.06,54.42)
GPIO85: length 24.5
  IN3 w0.089: v2(79.41,58.65) 80.12,58.65 80.17,58.7 85.61,58.7 86.44,57.88 87.3,57.88 87.84,57.33 92.54,57.33 92.77,57.56 v2(93.02,57.56)
  BOTTOM w0.089: 78.39,55.87 78.23,55.71 76.88,55.71 76.86,55.69 76.81,55.69
  BOTTOM w0.127: RP26.1 93.17,56.91 93.02,57.05 v2(93.02,57.56) ; 78.39,55.87 78.46,55.93 79.14,55.93 79.92,56.71 79.92,58.15 v2(79.41,58.65) ; 76.81,55.69 76.6,55.69 76.39,55.48 76.39,55.02 76.24,54.87 75.17,54.87 U16.N6
GPIO87: length 4.6
  TOP w0.127: v4(77.43,51.95) 77.43,51.91 R91.1
  IN1 w0.089: v5(77.04,52.43) 77.43,52.04 v4(77.43,51.95)
  IN4 w0.089: v5(77.04,52.43) 76.99,52.48 75.27,52.48 74.96,52.79 74.81,52.79 v2(74.13,53.47)
  BOTTOM w0.127: U16.R7 v2(74.13,53.47)
GPIO90: length 31.2
  TOP w0.127: v7(80.35,61.45) 80.12,61.68 v4(78.83,61.68)
  IN1 w0.089: v5(78.83,61.17) v4(78.83,61.68)
  IN3 w0.089: v5(87.08,60.79) 86.07,60.79 85.3,60.02 82.13,60.02 80.83,61.32 78.98,61.32 v5(78.83,61.17)
  IN4 w0.089: v2(79.23,61.32) 78.98,61.32 v5(78.83,61.17) ; v5(87.08,60.79) 87.08,60.91 v2(87.34,61.17)
  BOTTOM w0.089: U16.K2 77.65,56.28 78.15,56.28 78.24,56.19 78.39,56.19
  BOTTOM w0.127: 78.39,56.19 79.03,56.19 79.51,56.67 79.51,57.05 78.9,57.66 78.9,58.75 79.23,59.08 v2(79.23,61.32) ; v2(87.34,61.17) 87.65,61.17 88.9,59.91 89.22,59.91 90.33,58.81 95.66,58.81 R460.1 R459.2
GPIO91: length 12.5
  IN3 w0.089: v2(78.78,56.79) 79.05,57.07 79.06,57.06 79.07,57.06 79.29,57.06 79.38,56.98 84.4,56.98 84.4,56.98 85.19,56.98 85.44,56.73 86.67,56.73 v2(86.75,56.65)
  BOTTOM w0.127: U16.J1 78.73,56.74 v2(78.78,56.79) ; R274.1 89.1,56.6 88.09,56.6 R273.2 87.51,57.1 87.07,56.66 86.92,56.66 86.91,56.65 v2(86.75,56.65)
GPIO92: length 16.7
  IN3 w0.089: v2(79.18,56.79) 84.32,56.79 84.59,56.52 86.01,56.52 86.19,56.34 87.03,56.34 87.06,56.32 v2(87.06,56.34)
  BOTTOM w0.089: U16.K3 77.14,56.46 78.39,56.46
  BOTTOM w0.127: 78.39,56.46 78.91,56.46 79.18,56.73 v2(79.18,56.79) ; v2(87.06,56.34) 87.06,56.14 87.49,55.71 R278.2 87.94,56.03 88.17,56.27 89.42,56.27 89.6,56.44 91.12,56.44 91.64,56.97 R275.1
GPIO93: length 14.1
  BOTTOM w0.127: R266.2 84.3,58.78 83.29,58.78 R268.1 82.36,58.25 v6(81.77,58.83) 81.54,59.06 80.73,59.06 79.66,60.13 79.66,61.47 79.46,61.68 79.08,61.68 78.88,61.47 78.88,59.44 78.14,58.7 77.89,58.7 77.67,58.49 77.67,57.04 77.37,56.74 U16.J2
GPIO94: length 18.6
  IN3 w0.089: v2(93.41,57.56) 93.41,57.48 93.04,57.12 92.68,57.12 92.59,57.03 87.88,57.03 87.22,57.69 86.32,57.69 85.63,58.37 80.1,58.37 79.94,58.22 78.55,58.22 v2(78.5,58.28)
  BOTTOM w0.127: v6(94.12,58.3) 93.99,58.3 93.41,57.71 v2(93.41,57.56) 93.41,57.56 RP26.3 ; U16.G1 78.5,57.97 v2(78.5,58.28)
H_CPU_SVIDALRT_N: length 5.6
  BOTTOM w0.127: R284.1 35.21,54.56 35.75,55.1 36.38,55.1 36.64,55.35 38.21,55.35 38.49,55.63 39.74,55.63 40.04,55.33 U16.L62
H_CPUPWRGD: length 6.5
  BOTTOM w0.089: U16.C61 41.01,60.82 41.06,60.86 41.06,61.35 40.95,61.45 40.95,61.88 40.7,62.13
  BOTTOM w0.127: R255.2 39.95,65.86 v7(40.27,65.54) 40.27,64.39 40.47,64.19 40.47,62.36 40.7,62.13
H_PROCHOT#: length 7.7
  BOTTOM w0.127: U16.K63 38.32,56.03 38.21,56.14 38.01,56.14 37.91,56.03 37.69,56.03 37.61,56.11 37.61,56.54 37.42,56.72 37.1,56.72 36.97,56.6 36.97,56.09 36.87,55.99 36.43,55.99 36.34,56.08 36.34,56.42 36.21,56.54 35.95,56.54 35.7,56.29 35.7,56.06 35.6,55.96 35.42,55.96 35.11,56.27 34.76,56.27 34.6,56.11 34.6,55.87 R279.2
H_PROCHOT#_EC: length 6.7
  TOP w0.127: Q3.2 142.86,63.99 142.44,63.57 R17.1 142.2,62.84 v7(141.92,62.56) 141.44,62.08 141.44,61.96 140.85,61.37 v4(140.85,61.22)
  IN1 w0.089: v4(140.01,59.48) 140.01,59.61 140.85,60.46 v4(140.85,61.22)
H_VR_ENABLE_MCP: length 32.7
  IN3 w0.089: v2(22.44,51.9) 23.71,51.9 24.83,53.01 28,53.01 30.92,55.94 37.35,55.94 39.84,58.42 41.15,58.42 v2(41.34,58.24)
  IN4 w0.089: v2(46.34,65.1) 43.77,65.1 42.76,64.09 42.76,63.81 41.77,62.82 41.77,60.25 42.35,59.67 42.35,59.03 41.84,58.53 41.62,58.53 v2(41.34,58.24)
HDA_BITCLK: length 41.1
  TOP w0.127: R199.1 R198.1
  IN2 w0.089: v9(103.97,26.37) 103.31,27.03 103.31,27.33 102.54,28.11 82.69,28.11 79.58,31.22 71.36,31.22 71.08,31.5 71.08,32.87 72.46,34.26 72.46,34.28 73.24,35.06 v5(73.37,35.06)
  IN4 w0.089: v2(73.37,35.51) v5(73.37,35.06)
  BOTTOM w0.127: R359.1 v2(73.37,35.51)
HDA_BITCLK_CODEC: length 97.8
  TOP w0.127: R198.2 R197.2 102.96,26.05 102.8,25.89 v9(101.43,25.89) ; v6(16.92,30.12) 16.92,29.65 v7(20.63,25.94) 39.56,25.94 41.09,24.4 48.09,24.4 48.53,23.96 55.84,23.96 v9(56.6,23.2)
  IN2 w0.089: v9(56.6,23.2) 57.22,23.2 59.83,25.81 69.76,25.81 73.72,29.77 79.09,29.77 82.12,26.74 100.4,26.74 101.25,25.89 v9(101.43,25.89)
  BOTTOM w0.127: v6(16.92,30.12) 17.54,30.74 17.54,31.49 18.4,32.35 CN3.10
HDA_BITCLK_DSP: length 18.1
  TOP w0.127: v4(107.19,38.71) 107.19,39.51 106.64,40.06 106.64,40.46 C137.1 ; R199.2 v9(105.62,26.37) 105.65,26.34 v7(106.33,26.34)
  IN1 w0.089: v9(107.1,34.12) 107.4,34.42 107.76,34.42 108.09,34.75 108.09,37.81 v4(107.19,38.71)
  IN2 w0.089: v9(105.62,26.37) 104.95,27.04 104.95,29.03 104.82,29.16 104.82,31.84 v9(107.1,34.12)
HDA_BITCLK_R: length 9
  BOTTOM w0.127: U16.AW8 72.82,39.42 72.82,38.62 73.67,37.77 73.67,36.5 73.81,36.36 73.81,34.55 R359.2 73.18,34.11 v7(72.15,33.08) 72.04,32.97 EC59.1
HDA_RST#: length 42.5
  TOP w0.127: R211.1 R210.1 ; v9(67.65,31.32) 67.98,30.98 68.48,30.98 v7(68.49,30.99) 68.51,31.02 R178.1
  IN2 w0.089: v9(103.97,24.34) 102.96,25.35 102.96,27.16 102.35,27.77 82.55,27.77 79.45,30.87 68.1,30.87 v9(67.65,31.32)
HDA_RST#_CODEC: length 112.7
  TOP w0.127: v9(55.33,23.19) 48.22,23.19 47.77,23.64 40.78,23.64 39.39,25.02 20.1,25.02 18.83,26.29 17.69,26.29 v7(16.06,27.92) 16.06,28.22 14.18,30.1 14.18,30.1 13.61,30.68 13.61,33.04 13.31,33.34 13.31,35.56 14.18,36.44 17.29,36.44 18.15,35.59 v6(18.15,35.51) ; R210.2 R209.2 102.96,24.07 102.75,23.86 v9(101.43,23.86)
  IN2 w0.089: v9(55.33,23.19) 56.14,22.38 57.37,22.38 59.96,24.97 70.57,24.97 74.69,29.09 78.8,29.09 81.83,26.05 99.11,26.05 101.31,23.86 v9(101.43,23.86)
  BOTTOM w0.127: v6(18.15,35.51) 18.15,35.44 18.68,34.9 18.68,34.65 18.96,34.37 19.77,34.37 19.9,34.24 CN3.7
HDA_RST#_DSP: length 22.5
  TOP w0.127: v4(105.01,39.55) 104.89,39.55 104.69,39.36 U10.11 ; R211.2 v9(105.62,24.34) v7(106.39,24.34)
  IN1 w0.089: v4(105.01,39.55) 105.01,38.36 105.52,37.85 105.52,36.36 104.99,35.83 104.99,34.27 105.8,33.46 107.74,33.46 v9(107.9,33.61)
  IN2 w0.089: v9(105.62,24.34) 105.95,24.67 105.95,26.21 105.97,26.23 105.97,26.51 105.95,26.52 105.95,26.55 105.29,27.21 105.29,29.17 105.16,29.3 105.16,31.13 107.64,33.61 v9(107.9,33.61)
HDA_RST#_R: length 11.5
  TOP w0.127: R178.2 v7(68.51,34.8) 68.51,36.19 70.49,38.17 71.44,38.17 72.23,38.96 72.23,39.97 73.18,40.92 v2(73.18,41.04)
  IN1 w0.089: v2(73.18,41.04) 73.22,41.04 73.44,41.25 v5(73.44,41.3)
  IN4 w0.089: v5(73.44,41.3) 73.18,41.04 v2(73.18,41.04)
HDA_SDIN0: length 43
  TOP w0.127: R204.1 R203.1
  IN2 w0.089: v9(103.97,25.35) 104.25,25.64 104.25,28.75 103.87,29.14 83.11,29.14 79.28,32.97 74,32.97 73.8,33.18 73.8,33.66 74.3,34.17 74.3,35.31 v6(73.29,36.33)
  BOTTOM w0.127: U16.AY10 72.39,38.65 73.24,37.8 73.24,36.38 v6(73.29,36.33)
HDA_SDIN0_CODEC: length 108.9
  TOP w0.127: R203.2 R202.2 102.96,25.11 102.73,24.87 v9(101.43,24.87) ; v6(18.15,34.8) 17.61,35.34 17.61,35.58 17.14,36.06 14.64,36.06 14.36,35.78 14.36,33.3 14.56,33.1 14.56,30.26 v7(17.84,26.98) 18.78,26.98 20.35,25.41 39.54,25.41 40.94,24.02 47.93,24.02 48.38,23.58 55.59,23.58 55.97,23.19 v9(55.94,23.19)
  IN2 w0.089: v9(55.94,23.19) 56.35,22.79 57.29,22.79 59.86,25.35 70.16,25.35 74.24,29.43 78.94,29.43 81.98,26.4 99.91,26.4 v9(101.43,24.87)
  BOTTOM w0.127: CN3.9 18.9,33.95 18.15,34.7 v6(18.15,34.8)
HDA_SDIN0_DSP: length 20.8
  TOP w0.127: v4(107.02,40.21) 107.02,41.99 v7(107.43,42.4) 107.07,42.75 R138.2 ; R204.2 v9(105.62,25.35)
  IN1 w0.089: v4(107.02,40.21) 107.02,39.7 106.26,38.94 106.26,35.54 105.9,35.18 105.9,34.52 v9(106.26,34.17)
  IN2 w0.089: v9(106.26,34.17) 104.48,32.39 104.48,29.02 104.6,28.9 104.6,26.38 v9(105.62,25.35)
HDA_SDIN0_DSP_R: length 6.9
  TOP w0.127: U10.8 106.19,40.14 C133.1 106,41.35 106,42.36 R138.1 106.12,43.26 107.02,43.26 v7(107.43,43.67)
HDA_SDOUT: length 43.5
  TOP w0.127: R196.1 R195.1
  IN2 w0.089: v9(103.97,27.39) 102.9,28.45 82.83,28.45 79.61,31.68 71.99,31.68 71.46,32.21 71.46,32.75 72.97,34.26 73.12,34.26 73.75,34.88 73.75,35.36 73.56,35.55 72.31,35.55 v5(71.99,35.87)
  IN4 w0.089: v2(71.99,35.41) v5(71.99,35.87)
  BOTTOM w0.127: R358.1 72.73,34.57 72.73,35.23 72.55,35.41 v2(71.99,35.41)
HDA_SDOUT_CODEC: length 98.5
  TOP w0.127: R195.2 R194.2 102.96,27.04 102.83,26.9 101.94,26.9 v9(101.43,26.4) ; v9(56.32,24.03) 56.02,24.34 48.72,24.34 48.27,24.78 41.25,24.78 39.72,26.32 27.93,26.32 26.95,27.3 20.65,27.3 v7(20.63,27.31) 20.61,27.31 17.34,30.59 16.62,30.59 v6(16.22,30.18)
  IN2 w0.089: v9(56.32,24.03) 56.65,23.7 57.24,23.7 59.69,26.15 69.62,26.15 73.58,30.12 79.23,30.12 82.26,27.08 100.61,27.08 101.29,26.4 v9(101.43,26.4)
  BOTTOM w0.127: v6(16.22,30.18) 17.12,31.09 17.12,31.61 17.9,32.39 CN3.11
HDA_SDOUT_DSP: length 17
  TOP w0.127: v9(105.66,27.37) 105.64,27.39 R196.2 ; v4(107.69,38.71) 107.69,40.03 107.53,40.2 C138.1 108.41,40.58 v7(108.42,40.59)
  IN1 w0.089: v9(108.87,33.64) 108.87,33.84 108.52,34.19 108.52,37.88 v4(107.69,38.71)
  IN2 w0.089: v9(108.87,33.64) 108.87,33.02 108.09,32.24 107.45,32.24 106,30.79 106,27.71 v9(105.66,27.37)
HDA_SDOUT_R: length 8.8
  BOTTOM w0.089: 72.45,38.16 72.11,38.5 72.11,40.23 71.97,40.37 71.97,40.55 71.68,40.83 U16.AU11
  BOTTOM w0.127: R358.2 R357.2 71.26,35.56 71.49,35.79 72.35,35.79 72.78,36.22 72.78,37.83 72.45,38.16
HDA_SYNC: length 36.2
  TOP w0.127: R175.1 70.48,32.3 70.95,32.77 v7(71.05,32.77) 71.13,32.69 v9(71.82,32.69) ; R190.1 R189.1
  IN2 w0.089: v9(71.82,32.69) 72.35,32.16 79.61,32.16 82.97,28.8 103.58,28.8 v9(103.97,28.4)
HDA_SYNC_CODEC: length 96.7
  TOP w0.127: R189.2 R188.2 102.96,28.16 102.85,28.04 102.03,28.04 101.53,27.53 101.53,27.28 v9(101.43,27.18) ; v6(18.59,31.9) 18.29,31.9 17.58,31.19 17.58,30.88 19.68,28.78 v7(20.63,28.78) 21.55,28.78 22.65,27.68 27.11,27.68 28.09,26.7 39.87,26.7 41.41,25.16 48.57,25.16 49.02,24.72 56.2,24.72 v9(56.87,24.05)
  IN2 w0.089: v9(56.87,24.05) 57.1,24.05 59.55,26.5 69.43,26.5 73.39,30.46 79.37,30.46 82.4,27.43 101.19,27.43 v9(101.43,27.18)
  BOTTOM w0.127: v6(18.59,31.9) 18.87,31.9 19.4,32.42 CN3.8
HDA_SYNC_DSP: length 24.3
  TOP w0.127: v7(102.42,42.68) 103,43.25 C124.1 103.34,40.62 103.91,40.05 104.92,40.05 v4(105.01,39.96) 105.17,39.96 105.37,39.76 105.37,39.4 105.19,39.22 U10.10 ; v9(105.65,28.4) 105.6,28.45 R190.2
  IN1 w0.089: v9(108.4,33.64) 108.08,33.96 107.63,33.96 107.48,33.81 106.03,33.81 105.47,34.37 105.47,35.56 105.9,36 105.9,38 105.45,38.46 105.45,39.68 105.17,39.96 v4(105.01,39.96)
  IN2 w0.089: v9(105.65,28.4) 105.65,31.13 107.26,32.75 107.83,32.75 108.4,33.31 v9(108.4,33.64)
HDA_SYNC_R: length 12.5
  TOP w0.127: v6(70.67,35.82) 70.67,34.62 v7(69.68,33.63) 69.7,33.62 R175.2 R182.2
  BOTTOM w0.089: 72.3,37.7 71.93,38.07 71.93,40.14 U16.AV11
  BOTTOM w0.127: v7(70.34,35.18) 70.34,35.49 v6(70.67,35.82) 70.88,36.02 72.12,36.02 72.4,36.3 72.4,37.6 72.3,37.7
HWPG: length 154.5
  TOP w0.127: v4(87.23,49.23) 87.11,49.36 R103.1 ; v4(133.66,66.53) 133.84,66.7 141.23,66.7 v6(141.39,66.55) 141.56,66.38 R404.2 ; v9(130.63,61.8) R23.2 130.63,63.74 129.48,64.89 v4(129.32,64.89) C8.1
  IN1 w0.089: v4(87.23,49.23) 87.51,48.95 89.49,48.95 89.65,49.1 90.46,49.1 93.58,52.23 101.5,52.23 102.38,53.11 106.29,53.11 106.64,53.46 114.45,53.46 114.45,53.46 114.6,53.46 114.97,53.82 115.57,53.82 115.81,54.06 117.61,54.06 120,56.44 121.75,56.44 124.93,59.62 125.18,59.62 126.85,61.29 128.53,61.29 129.04,61.8 v9(130.63,61.8) ; v4(133.66,66.53) 133.54,66.4 130.83,66.4 v4(129.32,64.89) ; v9(130.06,36.12) 130.06,36.66 131.16,37.76 131.16,38.35 128.91,40.59 128.91,41.71 130.01,42.8 130.01,47.1 130.87,47.96 130.87,50.73 130.48,51.12 130.48,51.63 130.65,51.8 130.65,52.44 131.5,53.29 v9(131.5,53.33)
  IN2 w0.089: v5(99.91,30.28) 101.14,31.51 101.39,31.51 102.73,32.85 104.02,32.85 105.67,34.5 112.68,34.5 113.36,35.17 120.27,35.17 120.74,35.64 129.58,35.64 v9(130.06,36.12) ; v9(130.63,61.8) 130.63,60.57 131.3,59.9 131.3,54.11 131.5,53.91 v9(131.5,53.33)
  IN4 w0.089: v2(79.05,35.26) 82.27,35.26 85.86,31.67 95.62,31.67 96.43,30.87 97.16,30.87 97.75,30.28 v5(99.91,30.28)
  BOTTOM w0.127: R364.1 78.69,33.6 78.93,33.84 78.93,35.13 v2(79.05,35.26)
