# Allegro board dad13cmbag0-g-roger-165XL.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PCH_THRMTRIP#: length 10.5
  BOTTOM w0.127: R253.2 v6(44.84,67.01) 43.14,67.01 42.63,66.5 42.63,65.03 41.72,64.11 41.72,60.38 41.34,60 U16.D60
PCI_PME_N: length 11.4
  BOTTOM w0.089: 78.67,49.11 78.52,48.96 77.17,48.96 77.04,48.84 76.31,48.84 76.06,48.59 v2(76.06,48.54)
  BOTTOM w0.127: 78.67,49.11 78.67,49.11 80.51,49.11 80.81,49.41 81.95,49.41 82.72,50.18 86.24,50.18 86.28,50.22 TP93.1
PCIE_CLK_REQ0#: length 15.8
  BOTTOM w0.089: 78.45,51.78 77.62,51.78 77.36,52.04 U16.U2
  BOTTOM w0.127: RP31.5 89.12,50.62 TP89.1 88.73,51.01 87.18,51.01 86.47,51.72 86.47,52.05 86.29,52.23 86.29,52.76 85.94,53.12 84.57,53.12 84.32,53.36 82.47,53.36 82.06,53.76 80.82,53.76 78.84,51.78 78.45,51.78
PCIE_CLK_REQ1#: length 16.6
  IN3 w0.089: v2(75.38,50.61) 75.55,50.44 75.91,50.44 76.08,50.27 76.08,50.09 76.26,49.92 76.72,49.92 77.61,49.03 78.55,49.03 78.67,49.15 83.98,49.15 84.38,48.75 86.93,48.75 87.36,49.18 v2(87.36,49.53)
  BOTTOM w0.127: RP31.3 89.5,50.12 88.81,49.43 87.46,49.43 v2(87.36,49.53)
PCIE_CLK_REQ2#: length 135.3
  TOP w0.127: v6(182.69,27.13) 182.48,27.13 182.02,26.67 181.49,26.67 181.34,26.52 179.89,26.52 179.75,26.38 R213.1 177.64,26.26 Q42.3
  IN3 w0.089: v6(182.69,27.13) 182.5,27.32 182.5,30.22 181.22,31.5 181.22,39.17 179.56,40.82 179.21,40.82 178.99,40.61 168.98,40.61 161.45,48.14 161.44,48.14 161.37,48.21 144.73,48.21 141.25,44.73 138.42,44.73 137.43,45.72 136.55,45.72 136.1,45.26 136.1,44.42 135.37,43.69 132.17,43.69 130.71,45.15 115.51,45.15 111.56,49.1 104.18,49.1 102.6,50.68 90.5,50.68 v2(89.35,49.53)
  BOTTOM w0.127: RP31.1 89.37,49.55 v2(89.35,49.53) 89,49.18 86.42,49.18 85.68,49.92 82.84,49.92 81.95,49.03 81.95,48.92 81.37,48.34 80.86,48.34 80.56,48.64 79,48.64 78.86,48.5 U16.AD1
PCIE_CLK_REQ2#_R: length 7.6
  TOP w0.127: v6(174.28,24.08) 174.48,23.89 v6(174.89,23.89) 175.77,23.89 175.85,23.96 R200.1 177.76,24.85 R213.2 177.75,25.61 Q42.2
  BOTTOM w0.127: v6(174.28,24.08) 173.96,24.4 CN4.53
PCIE_CLK_REQ3#: length 14
  IN3 w0.089: v2(78.79,54.49) 79.41,53.88 85.81,53.88 86.7,52.99 v2(86.7,52.28)
  BOTTOM w0.127: U16.N1 v2(78.79,54.49) ; v2(86.7,52.28) 87.06,51.92 87.44,51.92 TP87.1 89.19,51.64 89.63,51.2 RP31.7
PCIE_CLK_REQ4#: length 14.2
  BOTTOM w0.089: U16.U5 75.44,52.58 77.43,52.58 77.48,52.53 77.48,52.53 77.65,52.36 77.65,52.36 77.68,52.33 77.68,52.13 77.85,51.96 78.25,51.96 78.39,52.1 78.45,52.1
  BOTTOM w0.127: 78.45,52.1 78.78,52.1 80.69,54.02 82.27,54.02 82.61,53.67 84.39,53.67 84.67,53.4 86.45,53.4 TP84.1 87.38,52.46 RP30.1
PCIE_CLK_REQ5#: length 12.3
  BOTTOM w0.127: RP30.3 87.49,53.11 86.98,53.62 84.78,53.62 84.36,54.04 84.36,54.13 83.96,54.54 82.53,54.54 82.03,55.05 80.96,55.05 78.57,52.66 77.86,52.66 77.52,52.99 U16.T2
PCIE_IREF: length 3.6
  TOP w0.305: v4(62.37,61.07) 61.76,61.68 v7(61.1,61.68) R27.2
  IN1 w0.305: v4(62.37,61.07) v5(61.78,61.07)
  IN4 w0.305: v2(62.17,61.06) 62.17,61.07 v5(61.78,61.07)
PCIE_PLLOBS1: length 2.1
  IN1 w0.089: v5(69.78,59.06) 69.89,59.16 v4(70.98,59.16)
  IN4 w0.089: v2(70.65,59.1) 69.87,59.1 69.83,59.06 v5(69.78,59.06)
PCIE_RCOMP: length 5.6
  TOP w0.305: v4(62.87,61.07) 62.87,61.5 v7(62.6,61.78) 62.06,62.31 60.42,62.31 R25.2
  IN1 w0.305: v4(62.87,61.07) v5(63.31,61.07)
  IN4 w0.305: v5(63.31,61.07) 63.05,61.32 v2(62.7,61.32)
  BOTTOM w0.305: U16.A27 62.3,61.71 v2(62.7,61.32)
PCIE_RXN3: length 127.7
  IN4 w0.089: v2(71.6,57.92) 71.69,58.01 72.04,58.01 72.6,57.45 72.6,55.47 73.17,54.91 76.33,54.91 76.5,55.07 77.34,55.07 80.47,51.95 85.68,51.95 86.7,50.92 104.43,50.92 104.9,50.45 117.4,50.45 117.76,50.09 132.08,50.09 132.97,49.2 149.06,49.2 150.13,50.27 152.07,50.27 152.9,49.45 158.76,49.45 160.81,47.4 164.7,47.4 167.78,44.32 167.78,43.74 175.12,36.4 175.12,28.3 174.52,27.71 174.52,27.32 174.84,27 174.96,27 v2(175.16,26.8)
  BOTTOM w0.114: v2(175.16,26.8) 175.16,26.88 174.98,27.06 174.04,27.06 173.89,26.9 CN4.43 ; U16.G11 v2(71.6,57.92)
PCIE_RXP3: length 127.8
  IN4 w0.089: v2(175.16,27.5) 175.16,27.35 175.02,27.21 174.92,27.21 174.72,27.41 174.72,27.62 175.32,28.22 175.32,36.48 167.98,43.82 167.98,44.4 164.78,47.6 160.9,47.6 158.85,49.65 152.98,49.65 152.16,50.47 150.05,50.47 148.98,49.41 133.06,49.41 132.17,50.3 117.84,50.3 117.48,50.65 104.99,50.65 104.51,51.13 86.79,51.13 85.76,52.15 80.55,52.15 77.43,55.27 76.41,55.27 76.25,55.11 73.25,55.11 72.81,55.56 72.81,57.54 72.13,58.21 71.71,58.21 71.6,58.33 v2(71.6,58.45)
  BOTTOM w0.114: CN4.41 173.89,27.4 174.03,27.26 175,27.26 175.16,27.42 v2(175.16,27.5)
PCIE_SLOT3_WAKE_N: length 128.4
  TOP w0.127: Q44.3 167.71,27.5 v6(167.04,26.83) 167.04,29.25 R193.1
  IN3 w0.089: v6(167.04,26.83) 167.75,27.54 167.75,30.54 166.58,31.7 166.58,32.59 166.71,32.72 166.71,36.82 165.14,38.38 160.41,38.38 158.43,40.37 158.43,42.22 157.24,43.41 155.81,43.41 154.75,42.35 150.61,42.35 148.18,39.92 146.23,39.92 144.26,37.95 v8(140.85,37.95)
  IN4 w0.089: v8(140.85,37.95) 140.44,38.36 136.38,38.36 135.49,39.25 128.78,39.25 128.6,39.43 125,39.43 124.46,38.89 115.9,38.89 114.02,37.01 111.69,37.01 110.95,36.28 105.88,36.28 103.29,33.68 97.04,33.68 96.3,34.42 96.3,36.35 95.21,37.44 95.21,39.9 94.82,40.29 89.06,40.29 v2(88.48,39.7)
  BOTTOM w0.089: U16.AU2 77.71,40.72 78.42,40.72 78.69,40.45 78.88,40.45
  BOTTOM w0.127: v6(167.04,26.83) 167.73,26.14 R385.1 ; R347.1 88.6,39.7 v2(88.48,39.7) 88.48,39.83 TP120.1 87.44,40.87 87.44,41.89 87.15,42.17 87.15,43.56 86.16,44.56 81.92,44.56 79.46,42.1 79.46,40.68 79.23,40.45 78.88,40.45
PCIE_TXN3: length 142.8
  IN4 w0.089: v2(58.56,61.37) 58.79,61.14 58.79,61.04 59.73,60.1 64.85,60.1 66.32,58.63 66.78,58.63 67.65,57.75 70.03,57.75 70.95,56.82 70.95,54.87 72.16,53.66 73.67,53.66 73.76,53.76 77.42,53.76 77.9,53.28 77.9,52.87 80.25,50.53 85.46,50.53 86.04,49.94 103.56,49.94 104.27,49.23 115.83,49.23 116.1,48.96 131.59,48.96 132.72,47.83 138.21,47.83 138.48,48.1 153.18,48.1 153.48,48.39 158.25,48.39 160.42,46.22 163.65,46.22 165.22,44.65 165.23,44.65 173.46,36.41 173.46,28.89 173.78,28.57 174.15,28.57 174.27,28.45 v2(174.27,28.3)
  BOTTOM w0.114: v2(174.27,28.3) 174.27,28.38 174.15,28.5 173.95,28.5 173.85,28.4 CN4.37 ; v2(58.56,61.37) 58.56,61.47 58.76,61.68 58.76,62 58.02,62.74 57.74,62.74 57.29,63.2 57.29,63.42 v7(56.72,63.99) 57.26,64.53 57.26,64.94 C240.1
PCIE_TXN3_C: length 9.5
  BOTTOM w0.114: C240.2 57.11,66.38 57.11,66.41 57.11,66.66 57.43,66.98 57.6,66.98 58.16,66.98 58.7,66.45 58.7,64.48 60.36,62.82 60.36,62.65 60.36,61.06 60.79,60.63 U16.C29
PCIE_TXP3: length 142.8
  IN4 w0.089: v2(59.4,61.4) 59.06,61.4 58.99,61.32 58.99,61.13 59.81,60.3 64.93,60.3 66.41,58.83 66.86,58.83 67.74,57.95 69.94,57.95 69.94,57.95 70.11,57.95 71.16,56.91 71.16,54.95 72.24,53.87 73.58,53.87 73.68,53.96 77.5,53.96 78.1,53.36 78.1,52.96 80.33,50.73 85.54,50.73 86.12,50.14 103.64,50.14 104.35,49.43 115.92,49.43 116.18,49.17 131.68,49.17 132.81,48.04 138.13,48.04 138.39,48.3 153.1,48.3 153.39,48.59 158.33,48.59 160.51,46.42 163.73,46.42 165.31,44.85 165.31,44.85 173.66,36.5 173.66,28.97 173.86,28.78 174.05,28.78 v2(174.27,29)
  BOTTOM w0.114: CN4.35 173.81,28.9 174,28.71 174.13,28.71 174.27,28.85 v2(174.27,29) ; v2(59.4,61.4) 59.4,61.5 58.96,61.93 58.96,62.08 58.1,62.95 57.83,62.95 57.5,63.27 57.5,63.5 v7(57.99,63.99) 57.46,64.51 57.46,64.94 C241.1
PCIE_TXP3_C: length 9.5
  BOTTOM w0.114: U16.B30 60.23,60.58 60.16,60.51 60,60.51 59.8,60.71 59.8,60.78 59.96,60.94 59.96,60.95 60.16,61.14 60.16,62.73 58.49,64.4 58.49,66.36 58.07,66.78 57.52,66.78 57.31,66.58 57.31,66.49 57.31,66.3 57.48,66.13 C241.2
PCIE_WAKE#: length 107.4
  TOP w0.127: Q43.3 168.61,25.21 168.82,25 168.82,24.76 168.86,24.72 170.51,23.07 v6(171.71,23.07)
  IN2 w0.089: v6(171.71,23.07) 171.1,23.07 169.07,25.1 166.58,25.1 164.55,23.07 164.55,22.38 163.16,20.99 156.4,20.99 155.79,21.59 155.79,24.67 154.72,25.73 154.72,26.93 154.14,27.51 153.17,27.51 149.59,31.09 v5(147.3,31.09)
  IN4 w0.089: v5(147.3,31.09) 145.73,32.67 145.73,35.79 142.3,39.22 136.2,39.22 135.57,39.86 128.84,39.86 128.8,39.9 124.8,39.9 124.27,39.36 115.7,39.36 113.82,37.48 111.48,37.48 111.13,37.14 110.04,37.14 109.71,36.81 105.37,36.81 104.76,37.42 104.76,39.62 104.34,40.03 103.87,40.03 101.69,42.22 v2(101.69,42.5)
  BOTTOM w0.127: R314.2 92.49,48.09 93,47.58 93.99,47.58 94.96,46.61 94.96,46.23 96.05,45.14 96.05,44.63 97.04,43.64 v7(100.49,43.64) 100.54,43.64 v2(101.69,42.5)
PCIE_WAKE#_R: length 18.1
  BOTTOM w0.076: 78.61,46.46 78.53,46.54 76.39,46.54 76.34,46.59 75.93,46.59 75.38,46.04 U16.AJ5
  BOTTOM w0.127: 78.61,46.46 78.77,46.3 79.44,46.3 79.65,46.51 81.47,46.51 82.15,47.2 82.15,47.74 82.8,48.38 87.14,48.38 87.82,47.71 R318.1 89.69,48.16 90.59,48.16 90.66,48.09 R314.1
PECI_EC: length 3.7
  TOP w0.127: R30.1 132.45,60.66 v7(133.06,60.05) 133.63,59.48 U4.B1
PECI_EC_R: length 105.5
  TOP w0.127: R30.2 130.64,60.66 129.99,61.31 129.99,63.73 129.46,64.26 127.98,64.26 127.77,64.47 127.77,65.1 127.29,65.59 126.32,65.59 124.75,64.01 v7(123.94,64.01) 122.69,62.77 v4(122.69,61.42)
  IN1 w0.089: v5(40.57,54.53) 41.02,54.08 41.89,54.08 43.01,55.2 43.01,56.49 44.61,58.09 68.44,58.09 68.87,57.66 70.37,57.66 70.77,58.07 71.84,58.07 72.6,58.83 75.93,58.83 76,58.9 76.25,58.9 79.34,55.81 79.87,55.81 79.88,55.81 79.89,55.81 80.5,55.2 83.45,55.2 84.74,56.49 91.43,56.49 91.88,56.94 102.73,56.94 103.2,56.47 110.14,56.47 110.37,56.7 116.06,56.7 116.29,56.93 117.36,56.93 119.2,58.77 120.67,58.77 122.11,60.2 122.11,60.56 122.69,61.14 v4(122.69,61.42)
  IN4 w0.089: v2(40.04,54.53) v5(40.57,54.53)
PLTRST#: length 153.3
  TOP w0.127: U9.2 88.43,38.69 88.29,38.83 ; v9(88.4,42.17) 88.4,41.43 89.23,40.6 R152.2 88.61,40.59 88.32,40.3 88.32,39.46 88.43,39.34 ; 88.43,39.34 U9.1 ; 88.43,39.34 88.29,39.2 88.29,38.83 ; v4(92.03,28.27) 91.97,28.27 88.98,31.27 84.67,31.27 v7(84.34,31.6) 83.86,32.08 83.86,37.04 84.41,37.6 86.8,37.6 87.89,38.69 88.15,38.69 88.29,38.83 ; R238.2 v6(188.94,16.08)
  IN1 w0.089: v4(92.03,28.27) 92.03,27.38 97.25,22.16 98.82,22.16 99.49,22.83 101.38,22.83 102.56,21.65 117.38,21.65 120.7,18.33 131.34,18.33 135.14,14.53 141.84,14.53 144.28,12.09 167.35,12.09 168.16,12.91 168.16,15.12 170.14,17.1 172.43,17.1 v9(173.19,17.86)
  IN2 w0.089: v9(173.19,17.86) 175.83,17.86 178.09,15.6 187.56,15.6 188.05,16.08 v6(188.94,16.08) ; v9(88.4,42.17) 87.37,43.2 87.37,44.4 85.52,46.25 79.5,46.25 79.18,46.56 76.04,46.56 75.84,46.36 74.85,46.36 74.41,46.8 v5(74.41,46.8)
  IN4 w0.089: v2(74.08,46.8) v5(74.41,46.8)
PLTRST#_R: length 10.3
  TOP w0.127: R238.1 v6(186.4,16.08)
  BOTTOM w0.127: v6(186.4,16.08) 185.1,17.38 185.1,20.1 184.55,20.65 CN4.68
PM_BATLOW#: length 25.4
  IN4 w0.089: v2(76.51,42.88) 76.74,42.88 78.01,41.61 78.01,40.09 78.7,39.4 80.38,39.4 81.98,37.8 86.17,37.8 86.6,38.23 89.24,38.23 90.59,39.58 v2(94.7,39.58)
  BOTTOM w0.127: v2(76.51,42.88) 76.18,43.22 U16.AN4 ; Q29.1 93.43,40.48 R349.1 94.33,39.58 v2(94.7,39.58) 95.08,39.58 v7(95.26,39.76)
PM_BATLOW_N: length 59.1
  TOP w0.127: v4(133.77,58.02) 133.77,57.97 134.26,57.48 U4.F1
  IN1 w0.089: v4(133.77,58.02) 133.77,58.09 133.46,58.4 131.71,58.4 131.2,57.89 127.18,57.89 125.81,56.52 125.46,56.52 124.88,55.94 124.88,55.59 123.75,54.46 123.43,54.46 120.99,52.02 116.85,52.02 116.2,51.37 109.63,51.37 109.07,50.82 103.45,50.82 102.79,50.16 94.87,50.16 91.2,46.49 91.2,44.67 v5(91.47,44.39)
  IN3 w0.089: v5(91.47,44.39) 91.52,44.44 v2(92.58,44.44)
  BOTTOM w0.127: v2(92.58,44.44) 92.58,44.06 93.56,43.08 Q29.3 94.51,43.08 R344.2 96.69,41.62 v7(97.27,42.19)
PM_TEST_RST_N: length 3.7
  IN1 w0.089: v4(78.88,48.21) 78.55,47.88 v5(78.55,47.75)
  IN3 w0.089: v5(78.55,47.75) 77.85,48.44 76.88,48.44 v2(76.11,49.21)
  BOTTOM w0.127: U16.AC4 v2(76.11,49.21)
POWER_SW_IN0#: length 151
  TOP w0.127: v4(111.34,58.7) 111.34,58.55 112.61,57.28 v7(112.79,57.28) 116.7,57.28 118.53,59.11 118.53,60.84 119.11,61.42 119.67,61.42 120.05,61.04 122.31,61.04 122.51,60.84 122.51,59.9 122.89,59.53 R475.2 123.15,59.57 124.24,60.66 D3.3 126.83,60.66 126.83,61.88 127.21,62.26 R18.1
  IN1 w0.089: v4(111.34,58.7) 110.96,59.08 108.24,59.08 107.96,58.81 106.23,58.81 105.55,59.49 94.19,59.49 93.76,59.92 93.76,60.41 91.35,62.82 89.19,62.82 88.2,63.81 87.64,63.81 86.65,62.82 86.65,62.06 85.29,60.7 82.24,60.7 81.44,61.5 81.44,61.6 80.83,62.21 80.83,62.67 79.61,63.89 78.22,63.89 77.3,62.97 74.08,62.97 73.97,62.87 72.25,62.87 71.87,62.49 69.58,62.49 68.49,61.4 65.75,61.4 64.27,59.92 57.87,59.92 57.41,60.38 50.51,60.38 49.08,61.8 47.03,61.8 45.81,60.58 42.3,60.58 41.39,61.5 39.23,61.5 38.64,60.91 38.64,58.62 36.68,56.65 36.68,49.73 29.75,42.81 22.17,42.81 19.42,40.06 19.42,38.51 18.58,37.67 14.77,37.67 v6(12.63,35.53)
  BOTTOM w0.127: v6(12.63,35.53) 13.19,34.97 13.19,34.35 13.4,34.14 CN3.20
PROC_DETECT#: length 9.1
  BOTTOM w0.089: U16.D61 40.69,60.27 40.37,60.58 40.37,61.22 40.27,61.32 39.79,61.32 39.53,61.57 39.53,61.68
  BOTTOM w0.127: 39.53,61.68 39.53,63.66 37.88,65.31 37.88,66.43 TP50.1
PROC_OPI_COMP: length 6
  BOTTOM w0.254: U16.AY15 69.39,38.15
  BOTTOM w0.305: R355.1 65.82,36.45 66.28,36.91 v7(67.12,36.91) 68.16,36.91 69.39,38.15
PS/2_CLK_TPAD: length 59.5
  TOP w0.127: RP11.2 156.35,21.88 156.47,22 156.47,22.11 156.33,22.25 155.19,22.25 154.84,22.6 154.84,23 EC10.1
  IN1 w0.089: v4(139.01,58.48) 139.32,58.79 140.2,58.79 140.42,58.58 141.87,58.58 142.66,57.79 143.65,57.79 144.42,58.56 145.01,58.56 145.39,58.18 145.39,56.24 144.96,55.81 144.96,52.38 144.41,51.82 144.41,43.51 145.35,42.57 146.84,42.57 150.14,39.28 150.14,38.22 154.84,33.52 154.84,26.49 153.95,25.6 153.95,24.64 v5(153.83,24.53) 153.94,24.41 153.94,24.07 154.33,23.69 154.69,23.69 154.86,23.52 154.86,23.41 154.77,23.32 v4(154.52,23.32)
  IN4 w0.089: v2(149.47,21.39) 149.78,21.39 149.87,21.48 149.87,22.36 150.54,23.03 153.6,23.03 153.97,23.41 153.97,24.38 v5(153.83,24.53)
PS/2_DAT_TPAD: length 60.2
  TOP w0.127: EC11.1 155.22,23 155.22,22.76 155.34,22.64 156.48,22.64 156.85,22.27 156.85,22.03 157,21.88 RP11.4
  IN1 w0.089: v4(155.55,23.32) 155.29,23.32 155.21,23.41 155.21,23.66 154.83,24.03 154.47,24.03 154.28,24.22 154.28,24.35 v5(154.46,24.53) 154.29,24.7 154.29,25.46 155.18,26.34 155.18,33.66 150.48,38.36 150.48,39.43 146.99,42.92 145.49,42.92 144.75,43.65 144.75,51.68 145.3,52.23 145.3,55.67 145.73,56.1 145.73,58.33 145.15,58.91 144.28,58.91 143.51,58.14 142.8,58.14 142.01,58.92 140.56,58.92 140.35,59.13 139.35,59.13 v4(139.01,59.48)
  IN4 w0.089: v2(150.62,21.39) 150.3,21.39 150.22,21.48 150.22,22.22 150.69,22.69 153.74,22.69 154.32,23.27 154.32,24.38 v5(154.46,24.53)
PS_ID: length 200
  TOP w0.127: v4(136.05,32.72) 136.08,32.72 135.42,33.38 135.42,35.03 135.9,35.51 137.65,35.51 137.94,35.81 137.94,36.75 138.39,37.19 138.39,38.48 138.99,39.08 145.06,39.08 145.18,39.2 145.18,40.78 146.52,42.12 146.52,42.98 v7(146.82,43.29) 147.44,43.91 148.28,43.91 148.78,44.41 148.78,47.4 147.81,48.37 147.81,50.4 148.65,51.24 148.65,53.07 147.28,54.44 147.28,55.83 146.43,56.68 146.43,58.89 146.3,59.02 146.3,59.4 v9(145.51,60.18) ; PR149.2 5.06,8.44 5.43,8.07 PR148.2 v4(5.93,8.07) ; v9(139.53,60.53) 139.51,60.51 U4.A10
  IN1 w0.089: v9(49.06,19.08) 47.38,20.76 15.94,20.76 8.49,13.31 v4(8.21,13.31) 6.87,11.97 6.87,8.56 6.38,8.07 v4(5.93,8.07) ; v9(130.26,26.12) 130.64,26.5 132.67,26.5 136.05,29.87 v4(136.05,32.72)
  IN2 w0.089: v9(130.26,26.12) 129.37,25.23 128.94,25.23 124.64,20.93 121.85,20.93 120.08,19.16 112.53,19.16 111.26,17.89 111.26,17.33 109.89,15.96 97.8,15.96 97.07,16.68 97.07,17.34 92.73,21.68 81.31,21.68 80.73,22.25 71.92,22.25 71.21,21.54 58.99,21.54 57.82,20.38 53.38,20.38 52.08,19.08 v9(49.06,19.08) ; v9(139.53,60.53) 139.71,60.53 139.92,60.75 144.95,60.75 v9(145.51,60.18)
PWR_DEBUG#: length 13.1
  TOP w0.127: R1.1 v6(37.27,65.21)
  IN4 w0.089: v2(37.22,65.99) 37.7,65.51 37.7,64.9 40.88,61.73 40.88,58.02 41.03,57.87 v2(41.68,57.87)
  BOTTOM w0.127: U16.H59 v2(41.68,57.87) ; v6(37.27,65.21) 37.22,65.26 TP57.1
REFPKG_OCC: length 10.8
  BOTTOM w0.127: R265.1 82.61,59.26 v6(81.77,60.1) 80.78,60.1 80.48,60.41 80.48,61.7 78.85,63.33 76.35,63.33 75.46,62.44 U16.A5
REGN_LDO: length 14
  TOP w0.254: v4(133,32.92) 132.83,33.1 PR102.1 ; PD5.2 126.58,25.76 126.58,27.33 PC95.1 v7(126.02,29.11) 126.15,29.24 127.04,29.24 127.25,29.46 v4(127.25,29.95)
  IN1 w0.254: v4(133,32.92) 133,32.69 131.07,30.76 130.77,30.76 129.96,29.95 v4(127.25,29.95)
REM_DIODE1_N: length 57.7
  TOP w0.254: Q6.1 56.03,52.59 53.65,52.59 53.27,52.21 C74.2 52.58,52.07 52.18,52.07 v7(51.8,52.46) 51.42,52.07 50.46,52.07 45.17,46.79 45.17,45.73 44.02,44.58 37.61,44.58 36.14,46.05 31.79,46.05 29.83,44.1 27.48,44.1 27.3,44.28 25.59,44.28 24.9,44.96 12.17,44.96 10.38,43.17 10.38,41.73 11.03,41.08 11.69,41.08 C132.2 12.11,40.94 12.3,40.75 U8.3
REM_DIODE1_P: length 57.9
  TOP w0.254: U8.2 12.54,41.25 12.07,41.72 C132.1 11.78,41.72 11.64,41.58 11.24,41.58 10.88,41.95 10.88,42.96 12.38,44.45 24.69,44.45 25.38,43.77 27.09,43.77 27.27,43.59 30.04,43.59 32,45.55 35.93,45.55 37.4,44.08 44.23,44.08 45.68,45.52 45.68,46.58 50.67,51.57 51.42,51.57 v7(51.8,51.19) 52.18,51.57 52.58,51.57 C74.1 53.87,51.43 Q6.3 54.65,51.77 54.99,51.43 54.99,50.54 55.25,50.27 55.86,50.27 56.19,50.6 Q6.2
REM_DIODE2_N: length 26
  TOP w0.127: C169.2 C168.2 14.43,20.03 Q17.1 v7(14.16,21.72) 13.24,22.64 12.76,22.64 12.23,23.16 12.23,26.92 10.22,28.94 10.22,37.14 12.83,39.75 U8.5
REM_DIODE2_P: length 28.8
  TOP w0.127: C169.1 C168.1 15.37,19.25 15.1,18.98 Q17.2 12.84,18.98 Q17.3 12.18,22.71 11.69,23.19 v7(11.69,25.18) 11.35,25.52 11.35,27.07 9.87,28.55 9.87,37.63 12.48,40.25 U8.4
RFLED#: length 6.6
  BOTTOM w0.127: TP121.1 180.81,39.35 182.46,37.7 182.46,36.63 182.23,36.4 181.44,36.4 181.19,36.15 CN4.6
RSMRST#: length 123.7
  TOP w0.127: R166.1 R167.2 73.12,34.11 73.62,33.61 73.62,33.23 73.9,32.95 74.48,32.95 74.76,33.23 74.76,35.08 v7(75.42,35.74) v6(76.16,36.48) ; v4(142.68,60.93) 142.51,60.76 142.49,60.76 141.21,59.48 U4.B13
  IN1 w0.089: v5(123.57,62.2) 123.57,62.5 125.26,64.19 129.63,64.19 131.36,65.92 138.64,65.92 141.08,63.48 142.48,63.48 143.14,62.82 143.14,61.34 142.73,60.93 v4(142.68,60.93)
  IN2 w0.089: v5(112.61,36.1) 112.51,36.2 111.8,36.2 111.67,36.08 104.98,36.08 103.39,34.49 102.34,34.49 99.23,31.37 98.72,31.37 98.41,31.69 97.33,31.69 96.84,31.2 84.01,31.2 79.87,35.34 76.82,35.34 76.16,36 v6(76.16,36.48)
  IN4 w0.089: v5(123.57,62.2) 123.31,61.94 v2(123.31,61.94) ; v5(112.61,36.1) 112.61,35.89 112.89,35.62 115.91,35.62 118.22,37.93 121.5,37.93 121.83,37.6 124.39,37.6 125.34,38.55 v2(128.06,38.55)
  BOTTOM w0.089: 74.86,38.26 74.35,38.77 74.35,39.45 U16.AW6
  BOTTOM w0.127: 74.86,38.26 75.12,38 75.12,37.44 76.08,36.48 v6(76.16,36.48) ; v2(123.31,61.94) 123.31,59.2 122.67,58.55 122.67,48.77 128.18,43.27 128.18,38.66 v2(128.06,38.55)
RSVD_PGDMON: length 3.1
  TOP w0.127: TP29.1 v4(72.63,46.05) 72.76,46.18 R120.1
  IN1 w0.089: v5(72.29,45.58) 72.29,45.72 v4(72.63,46.05)
  IN4 w0.089: v5(72.29,45.58) 72.09,45.38 v2(72.09,45.29)
  BOTTOM w0.127: v2(72.09,45.29) 71.79,44.99 U16.AL11
RTC_RST#: length 13.3
  TOP w0.127: C161.1 R179.1 72.73,31.96 72.15,32.54 72.15,33.3 71.94,33.51 71.43,33.51 71.21,33.74 71.21,37.22 72.96,38.97 v7(72.96,39.86) 73.85,40.75 v2(73.85,41.04)
  IN1 w0.089: v2(73.85,41.04) 74.13,40.76 v5(74.13,40.67)
  IN4 w0.089: v2(73.85,41.04) 73.93,41.04 74.13,40.84 v5(74.13,40.67)
RTC_X1: length 14.3
  BOTTOM w0.089: U16.AW5 75.75,39.37 75.75,38.84 75.87,38.73
  BOTTOM w0.127: Y3.1 85.22,34.94 85.09,34.82 84.17,34.82 83.93,34.57 83.67,34.57 C261.2 83.01,34.76 R366.1 82.02,34.55 81.02,34.55 80.48,35.09 80.48,35.82 79.13,37.16 78.4,37.16 77.87,37.7 76.9,37.7 75.87,38.73
RTC_X2: length 14.1
  BOTTOM w0.127: U16.AY5 75.43,38.71 76.82,37.32 77.71,37.32 78.24,36.78 78.97,36.78 80.1,35.66 80.1,34.93 80.86,34.17 82.04,34.17 R366.2 83.01,33.98 C267.2 83.69,34.19 84.09,34.19 84.33,34.43 85.09,34.43 85.22,34.31 Y3.4
RUN_ON: length 309.4
  TOP w0.127: PR230.1 126.44,45.54 126.83,45.93 v4(126.83,46.05) ; v9(28.1,45.93) 28.1,45.98 25.94,48.14 Q38.2 ; v4(172.55,46.05) 178.78,46.05 180.3,44.53 180.3,41.95 180.05,41.69 180.05,41.27 180.34,40.97 184.36,40.97 185.06,40.28 185.06,39.03 187.14,36.95 PR84.1 192.19,36.61 191.78,36.2 190.18,36.2 189.29,35.31 189.29,33.38 190.79,31.88 195.92,31.88 196.76,31.05 196.76,21.98 197.55,21.19 197.55,18 PR128.1 ; v4(95.84,48.7) 95.62,48.7 95.33,48.98 PR32.1 95.33,49.36 94.06,50.63 D11.2
  IN1 w0.089: v5(125.56,55.86) 127.4,57.7 134.64,57.7 134.7,57.75 135.61,57.75 135.7,57.84 135.7,58.29 v9(135.51,58.48) ; v5(95.84,47.45) v4(95.84,48.7) ; v5(147.74,63.32) 147.74,62.29 147.87,62.15 151.6,62.15 152.18,61.57 153.69,61.57 155.22,60.04 155.22,56.04 160.49,50.78 168.26,50.78 169.55,49.48 169.55,49.21 170.85,47.91 172.29,46.47 172.55,46.2 v4(172.55,46.05) ; v5(127.11,48.45) 127.11,47.32 126.83,47.05 v4(126.83,46.05)
  IN2 w0.089: v5(147.74,63.32) 146.58,63.32 146.13,62.87 135.82,62.87 135.32,62.36 135.32,59.26 135.51,59.07 v9(135.51,58.48) ; v9(28.1,45.93) 28.13,45.9 v5(28.13,44.84)
  IN3 w0.089: v5(127.11,48.45) 127.01,48.45 126.38,49.08 120.96,49.08 119.49,47.6 115.12,47.6 114.18,48.54 114.18,49.07 113.92,49.33 113.42,49.33 v2(113.01,48.92) ; 85.56,44.1 83.15,44.1 81.95,42.91 76.95,42.91 76.01,43.84 76.01,44.05 75.57,44.48 74.64,44.48 74.1,43.95 73.54,43.95 72.68,44.81 72.68,45.75 71.69,46.74 71.69,47.12 70.11,48.7 70.11,53.55 67.87,55.8 67.87,56.89 67.14,57.61 65.06,57.61 64.3,58.37 44.46,58.37 42.99,56.9 42.99,50.25 42.15,49.41 41.16,49.41 40.7,49.86 36.64,49.86 34.1,47.32 34.1,46.69 32.17,44.76 28.2,44.76 v5(28.13,44.84) ; 85.56,44.1 85.56,43.64 86.07,43.13 89.19,43.13 91.75,40.57 92.87,40.57 v8(94.57,38.87) ; 85.56,44.1 85.95,44.49 90.58,44.49 91.25,43.82 98.13,43.82 v2(98.43,44.12) 99.7,44.12 100.67,43.16 103.85,43.16 104.13,42.88 104.59,42.88 104.76,43.06 104.76,43.67 100.97,47.45 v5(95.84,47.45)
  IN4 w0.089: v2(151.33,64.72) 150.05,64.72 148.68,63.35 147.77,63.35 v5(147.74,63.32) ; v2(94.73,33.09) 94.73,36.17 94.57,36.33 v8(94.57,38.87) ; v2(126.1,55.88) 125.86,55.88 125.84,55.86 v5(125.56,55.86) ; v2(126.58,48.47) 126.6,48.45 v5(127.11,48.45)
  BOTTOM w0.127: v2(126.58,48.47) 126.58,55.4 v2(126.1,55.88) ; v2(98.43,44.12) 98.49,44.18 100.75,44.18 102.19,42.73 102.19,42.35 102.36,42.18 104.11,42.18 104.66,42.73 104.66,44.05 v7(104.91,44.3) 107.68,47.07 112.35,47.07 112.79,47.5 112.79,48.7 v2(113.01,48.92)
RUN_ON_R: length 14.3
  TOP w0.127: PU2.5 100.05,48.32 100.11,48.26 100.11,46.64 99.96,46.49 99.37,46.49 99.2,46.66 99.2,48.14 99.25,48.19 PU2.3 ; v4(97.24,49.47) 96.85,49.47 96.61,49.23 PR32.2 96.11,50.11 D11.1 D10.1 v7(96.96,52.4)
  IN1 w0.089: v4(99.25,49.45) 99.23,49.47 v4(97.24,49.47)
SATA_IREF: length 5.6
  BOTTOM w0.305: R263.1 74.64,64.72 73.62,63.71 72.48,63.71 71.08,62.31 71.08,61.89 U16.A12
SATA_PLLOBS0: length 6.6
  TOP w0.127: TP7.1 v4(75.91,56.72)
  IN1 w0.089: v4(75.91,56.72) 75.59,56.72 75.49,56.83 75.48,56.83 75.17,57.14 73.19,57.14 72.77,56.72 72.7,56.72 72.48,56.49 72.48,55.71 72.17,55.4 v5(72.07,55.4)
  IN4 w0.089: v5(72.07,55.4) 71.9,55.57 v2(71.6,55.57)
SATA_PLLOBS1: length 8.8
  TOP w0.127: v4(76.11,58.63) 76.62,58.12 TP6.1
  IN1 w0.089: v4(76.11,58.63) 75.92,58.44 72.5,58.44 71.92,57.87 71.08,57.87 v5(70.9,57.69)
  IN4 w0.089: v2(72.08,56.56) 71.79,56.85 71.51,56.85 70.9,57.46 v5(70.9,57.69)
  BOTTOM w0.127: U16.K10 v2(72.08,56.56)
SATA_RCOMP: length 5.7
  IN3 w0.305: v2(70.93,60.91) 70.93,62.4 v2(73.62,65.1)
  BOTTOM w0.305: v2(70.93,60.91) 70.93,60.55 U16.C12
SATA_RXN2: length 99.4
  TOP w0.127: C89.1 169.31,49.16 168.5,49.16 v4(168.43,49.09)
  IN1 w0.114: v4(168.43,49.09) 168.4,49.06 v5(167.99,49.06)
  IN4 w0.114: v5(167.99,49.06) 167.9,49.15 166.89,49.15 166.18,49.85 160.75,49.85 159.49,51.11 153.96,51.11 153.12,51.95 149.41,51.95 148.59,51.12 134.92,51.12 134.44,51.6 133.35,51.6 133.14,51.81 118.46,51.81 118.16,52.11 105.61,52.11 105.06,52.66 88.01,52.66 86.49,54.18 80.73,54.18 79.1,55.81 78.7,55.81 78.26,56.24 76.41,56.24 76.21,56.44 75.07,56.44 74.9,56.61 74.57,56.61 74.5,56.54 74.5,56.54 v2(74.45,56.49)
SATA_RXN2_C: length 6.7
  TOP w0.127: C89.2 170.97,49.16 171.22,49.16 171.49,48.89 v6(171.49,48.84)
  BOTTOM w0.127: v6(171.49,48.84) 171.17,49.16 169.91,49.16 169.74,49 169.74,48.4 169.26,47.92 168.65,47.92 168.39,47.65 CON1.25
SATA_RXP2: length 99.4
  TOP w0.127: C83.1 169.31,49.43 168.97,49.43 v4(168.87,49.52)
  IN1 w0.114: v5(167.98,49.58) 168.36,49.58 168.42,49.52 v4(168.87,49.52)
  IN4 w0.114: v5(167.98,49.58) 167.89,49.49 167.03,49.49 166.33,50.19 160.89,50.19 159.64,51.45 154.1,51.45 153.26,52.29 149.27,52.29 148.44,51.46 135.06,51.46 134.58,51.95 133.49,51.95 133.29,52.15 118.6,52.15 118.3,52.46 105.75,52.46 105.2,53.01 88.16,53.01 86.64,54.53 80.87,54.53 79.25,56.15 78.84,56.15 78.41,56.58 76.56,56.58 76.35,56.79 75.21,56.79 75.04,56.95 74.65,56.95 v2(74.46,57.14)
SATA_RXP2_C: length 6.7
  TOP w0.127: C83.2 170.97,49.43 171.25,49.43 171.49,49.67 v6(171.49,49.72)
  BOTTOM w0.127: CON1.23 168.39,48.45 168.65,48.18 169.15,48.18 169.48,48.51 169.48,49.11 169.8,49.43 171.2,49.43 v6(171.49,49.72)
SATA_TXN2: length 108.7
  TOP w0.127: C102.2 169.36,46.17 168.96,46.17 168.76,46.36 v4(168.76,46.43)
  IN1 w0.114: v5(168.35,46.45) 168.37,46.43 v4(168.76,46.43)
  IN4 w0.114: v2(69.72,61.07) 69.58,60.93 69.58,60.81 70.47,59.92 71.64,59.92 72.17,59.39 72.45,59.39 74.15,57.69 74.15,56.29 74.26,56.18 76.15,56.18 76.42,55.92 77.8,55.92 78.27,55.45 78.75,55.45 80.52,53.69 86.28,53.69 87.88,52.09 104.92,52.09 105.39,51.62 117.92,51.62 118.25,51.29 132.57,51.29 133.41,50.45 148.65,50.45 149.65,51.45 152.68,51.45 153.52,50.61 159.26,50.61 161.27,48.59 165.16,48.59 167.45,46.31 168.2,46.31 v5(168.35,46.45)
SATA_TXN2_C: length 4.7
  IN1 w0.114: v5(170.29,46.5) 170.48,46.69 v4(170.66,46.69)
  IN4 w0.114: v5(170.29,46.5) 170.25,46.46 v2(169.92,46.46)
  BOTTOM w0.127: CON1.31 168.39,45.25 168.65,44.98 168.87,44.98 169,45.11 169,45.96 169.3,46.25 169.71,46.25 v2(169.92,46.46)
SATA_TXP2: length 108.8
  TOP w0.127: C111.2 169.52,45.9 168.91,45.9 v4(168.76,45.76)
  IN1 w0.114: v4(168.76,45.76) 168.75,45.78 168.35,45.78 v5(168.35,45.78)
  IN4 w0.114: v5(168.35,45.78) 168.16,45.97 167.3,45.97 165.02,48.25 161.13,48.25 159.11,50.27 153.38,50.27 152.54,51.11 149.79,51.11 148.79,50.11 133.27,50.11 132.43,50.94 118.1,50.94 117.77,51.27 105.25,51.27 104.78,51.75 87.73,51.75 86.14,53.34 80.37,53.34 78.61,55.11 78.13,55.11 77.66,55.57 76.27,55.57 76.01,55.84 74.12,55.84 73.81,56.15 73.81,57.55 72.31,59.05 72.03,59.05 71.5,59.58 70.33,59.58 69.39,60.52 v2(69.08,60.52)
SATA_TXP2_C: length 4.7
  IN1 w0.114: v4(170.66,45.55) 170.5,45.55 v5(170.31,45.74)
  IN4 w0.114: v5(170.31,45.74) 170.28,45.77 v2(169.92,45.77)
  BOTTOM w0.127: CON1.33 168.39,44.45 168.65,44.72 168.98,44.72 169.27,45 169.27,45.85 169.41,45.99 169.7,45.99 v2(169.92,45.77)
SDIO_CLK: length 115.2
  TOP w0.127: v6(174.51,42.04) 173.44,43.11 R336.1 R461.1
  IN4 w0.089: v6(174.51,42.04) 173.71,42.04 172.4,43.36 172.4,47.1 171.08,48.42 171.08,50.35 169.86,51.57 169.86,53.2 169.21,53.85 168.06,53.85 167.68,53.47 166,53.47 165.47,54 162.14,54 160.94,55.2 156.04,55.2 155.66,55.58 155.62,55.58 140.75,55.58 139.74,56.6 119.57,56.6 118.48,55.5 106.64,55.5 105.89,56.26 92.36,56.26 92.15,56.46 89.56,56.46 88.83,57.19 87.64,57.19 86.98,57.85 85.27,57.85 84.85,58.27 81.01,58.27 79.96,59.32 77.01,59.32 77,59.32 77,59.32 76.71,59.03 v2(76.71,59.03)
  BOTTOM w0.127: R478.1 174.51,41.55 v6(174.51,42.04) RP35.3
SDIO_CMD: length 114.5
  TOP w0.127: R337.1 174.46,42.75 v6(175.16,42.04)
  IN4 w0.089: v6(175.16,42.04) 174.45,41.33 173.94,41.33 172.04,43.23 172.04,46.82 170.74,48.12 170.74,50.18 167.79,53.13 162.33,53.13 160.87,54.59 156.13,54.59 155.48,55.24 155.19,55.24 155.19,55.24 140.11,55.24 139.73,55.62 135.38,55.62 135.16,55.4 127.76,55.4 127.51,55.15 122.35,55.15 121.96,55.53 119.01,55.53 118.64,55.16 106.5,55.16 105.75,55.91 92.21,55.91 92,56.12 89.42,56.12 88.69,56.85 87.5,56.85 86.84,57.51 85.08,57.51 84.69,57.9 80.89,57.9 79.81,58.97 77.14,58.97 76.69,58.53 76.39,58.53 v2(76.06,58.2)
  BOTTOM w0.127: R479.1 175.16,41.55 v6(175.16,42.04) RP35.1
SDIO_D0: length 118.5
  TOP w0.127: v6(175.83,42.04) 175.47,42.4 R338.1
  IN4 w0.089: v2(76.71,59.68) 80.1,59.68 81.16,58.62 85.01,58.62 85.43,58.2 87.12,58.2 87.78,57.54 88.97,57.54 89.7,56.81 v2(91.02,56.81) 92.31,56.81 92.51,56.6 106.04,56.6 106.79,55.85 118.29,55.85 119.39,56.95 139.91,56.95 140.94,55.92 154.91,55.92 154.91,55.92 155.76,55.92 155.76,55.92 155.83,55.92 156.19,55.55 161.25,55.55 162.44,54.36 169.19,54.36 170.59,52.96 170.59,51.93 172.4,50.12 172.4,47.73 172.76,47.38 172.76,44.18 173.64,43.29 174.71,43.29 175.98,42.02 v6(175.83,42.04)
  BOTTOM w0.127: 91.02,57.49 R272.2 ; 91.02,57.49 v2(91.02,56.81) ; 91.02,57.49 90.93,57.59 90.15,57.59 R271.1 89.37,58.36 v7(89.37,59.01) ; R480.1 176.36,41.64 175.98,42.02 v6(175.83,42.04)
SDIO_D1: length 119.8
  TOP w0.127: R339.1 176.49,43.24 v6(177.73,41.99)
  IN4 w0.089: v2(76.06,59.03) 76.06,59.57 76.57,60.08 80.21,60.08 81.27,59.01 86.79,59.01 87.92,57.88 89.12,57.88 89.85,57.15 92.47,57.15 92.68,56.95 106.19,56.95 106.94,56.19 118.09,56.19 119.21,57.31 140.12,57.31 141.16,56.27 154.77,56.27 156.02,56.27 156.37,55.91 161.48,55.91 162.52,54.87 169.35,54.87 171,53.22 171,52.05 172.76,50.3 172.76,47.88 173.1,47.54 173.1,44.34 173.8,43.64 174.89,43.64 176.09,42.44 176.11,42.44 176.38,42.17 176.38,42.15 176.57,41.97 177.71,41.97 v6(177.73,41.99)
  BOTTOM w0.127: R481.1 177.73,41.72 v6(177.73,41.99) 176.82,41.99 176.29,42.52 RP36.3
SDIO_D2: length 118.8
  TOP w0.127: R340.1 177.51,42.88 v6(178.39,41.99)
  IN4 w0.089: v2(76.71,60.41) 76.76,60.46 80.33,60.46 81.44,59.35 86.94,59.35 88.07,58.22 89.26,58.22 89.99,57.49 92.64,57.49 92.84,57.29 106.38,57.29 107.13,56.53 117.93,56.53 119.05,57.65 140.33,57.65 141.37,56.61 154.62,56.61 156.16,56.61 156.48,56.29 161.63,56.29 162.52,55.4 169.38,55.4 171.71,53.07 171.71,52.02 173.14,50.6 173.14,48.04 173.44,47.73 173.44,44.51 173.92,44.02 175.02,44.02 176.64,42.4 177.99,42.4 v6(178.39,41.99)
  BOTTOM w0.127: RP36.1 176.94,42.73 177.21,42.46 177.92,42.46 v6(178.39,41.99) R482.1
SDIO_D3: length 118.2
  TOP w0.127: R341.1 178.52,42.78 v6(179.05,42.24)
  IN4 w0.089: v2(77.38,58.65) 78.8,58.65 79.13,58.32 79.95,58.32 80.72,57.55 84.55,57.55 84.93,57.17 86.69,57.17 87.36,56.51 88.55,56.51 89.28,55.78 91.76,55.78 91.97,55.57 102.64,55.57 103,55.21 105.92,55.21 106.31,54.82 118.81,54.82 119.11,55.12 121.5,55.12 121.86,54.77 127.61,54.77 127.9,55.05 135.3,55.05 135.52,55.27 139.58,55.27 139.96,54.89 155.34,54.89 156,54.23 160.49,54.23 162,52.72 167.69,52.72 170.27,50.14 170.27,47.86 171.69,46.44 171.69,43.1 174.04,40.75 178.17,40.75 179.05,41.64 v6(179.05,42.24)
  BOTTOM w0.127: R477.1 180.44,41.36 R483.1 179.41,41.89 v6(179.05,42.24) ; U16.E2 77.36,58.67 v2(77.38,58.65)
SDIO_WLAN_WAKE: length 8
  BOTTOM w0.127: Q32.1 170.77,30.95 R370.2 170.53,31.65 170.09,32.09 v7(170.09,32.41) 170.09,33.35 170.55,33.81 171.21,33.81 171.97,33.05 171.97,32.48 172.04,32.4 CN4.21
SDIO_WLAN_WAKE_L: length 126.3
  IN3 w0.089: v8(156.47,47.45) 156.45,47.43 155.61,47.43 155.31,47.13 144.98,47.13 141.26,43.41 136.51,43.41 135.72,42.63 130.95,42.63 129.42,44.15 115.1,44.15 111.34,47.91 103.41,47.91 101.61,49.71 92.62,49.71 91.45,48.54 84.31,48.54 84.02,48.84 77.47,48.84 76.58,49.73 75.36,49.73 75.3,49.66 v2(74.73,49.66)
  IN4 w0.089: v2(171.03,28.66) 172.63,30.26 172.63,36.1 164.98,43.74 164.58,43.74 162.77,45.55 159.88,45.55 157.68,47.74 156.76,47.74 v8(156.47,47.45)
  BOTTOM w0.127: R386.1 168.74,27.79 168.37,28.16 ; 168.37,28.16 168.87,28.66 v2(171.03,28.66) ; 168.37,28.16 168.03,28.5 168.03,30.73 R369.2 168.5,32.08 v7(168.49,32.08)
SIO_EXT_SCI#: length 75.3
  TOP w0.127: v4(139.05,46.66) 138.64,47.07 D15.2
  IN1 w0.089: v4(139.05,46.66) 139.05,46.66 v5(139.05,41.97)
  IN3 w0.089: v2(77.69,44.95) 77.73,44.98 81.04,44.98 81.5,44.53 81.75,44.53 82.84,45.62 90.71,45.62 91.75,46.66 v2(92.42,46.66) 92.52,46.66 94.24,48.39 100.85,48.39 103.69,45.55 104.96,45.55 108.42,42.09 129.78,42.09 130.95,40.92 135.65,40.92 136.69,41.97 v5(139.05,41.97)
  BOTTOM w0.127: v2(92.42,46.66) 92.42,46.19 R326.1 92.8,45.8 92.92,45.8 TP112.1 ; v2(77.69,44.95) 77.69,44.21 77.48,44 U16.AM2
SIO_PWRBTN#: length 122.2
  TOP w0.127: D1.2 v4(147.15,62.77)
  IN1 w0.089: v4(147.15,62.77) 146.64,63.28 146.64,63.45 146.53,63.56 146.11,63.56 145.81,63.25 145.81,62.56 146.89,61.48 146.89,60.22 147.96,59.15 147.96,55.53 147.16,54.72 147.16,51.88 146.32,51.03 146.32,45.32 150.33,41.3 v9(150.33,40.97)
  IN2 w0.089: v9(150.33,40.97) 150.61,40.7 150.61,39.76 150.3,39.45 150.3,37.57 149.36,36.63 144.33,36.63 144.05,36.91 138.77,36.91 138.03,37.65 136.61,37.65 136.2,37.24 134.17,37.24 133.54,36.61 133.16,36.61 132.78,36.99 129.45,36.99 129.07,36.61 120.38,36.61 119.97,36.2 113.7,36.2 113.22,36.68 111.01,36.68 110.87,36.55 104.78,36.55 103.21,34.98 101.84,34.98 100.82,33.96 97.37,33.96 96.48,34.85 96.48,36.12 94.02,38.59 v5(91.73,38.59) 90.36,38.59 90.21,38.43 85.76,38.43 85.06,37.74 81.81,37.74 79.79,39.76 75.73,39.76 75.09,40.39 75.09,41.12 75.22,41.25 75.22,42.93 74.46,43.69 74.46,44.78 v5(74.61,44.94)
  IN4 w0.089: v5(91.73,38.59) v2(90.87,38.59) ; v2(74.28,44.94) v5(74.61,44.94)
  BOTTOM w0.127: R348.1 91.26,39.65 v7(91.04,39.43) 90.87,39.25 v2(90.87,38.59)
SIO_RCIN#: length 71.4
  TOP w0.127: 133.06,47.58 132.62,47.58 132.5,47.45 v4(132.29,47.45) ; R86.1 v9(81.25,52.53)
  IN1 w0.089: v4(132.29,47.45) 131.41,46.57 131.41,41.64 v9(131.33,41.56) ; v9(81.25,52.53) 81.1,52.38 78.37,52.38 78.14,52.15 v5(78.14,51.85)
  IN2 w0.089: v9(131.33,41.56) 128.66,41.56 128.23,41.13 125.38,41.13 124.62,41.89 117.33,41.89 116.76,41.32 108.28,41.32 107.17,42.42 107.17,44.38 105.67,45.88 101.97,45.88 98.02,49.83 89.59,49.83 89.25,50.17 84.08,50.17 82.66,51.59 82.66,52.3 82.6,52.36 82.6,52.89 82.46,53.04 81.59,53.04 81.25,52.69 v9(81.25,52.53)
  IN4 w0.089: v2(76.06,51.47) 76.31,51.72 78.01,51.72 v5(78.14,51.85)
  BOTTOM w0.127: U16.V4 v2(76.06,51.47)
SIO_SLP_A#: length 2.2
  TOP w0.127: TP33.1 75.5,44 75.14,44.35 v4(75.14,44.4)
  IN1 w0.089: v5(75.52,44.99) 75.14,44.61 v4(75.14,44.4)
  IN4 w0.089: v5(75.52,44.99) 75.16,44.99 v2(75.11,44.94)
SIO_SLP_LAN#: length 22.3
  IN1 w0.089: v5(73.9,45.9) 74.26,46.26 74.41,46.26 74.79,46.64 74.79,47.02 74.97,47.2 75.98,47.2 76.15,47.03 76.83,47.03 76.92,47.12 78.04,47.12 78.29,46.87 79.26,46.87 79.77,46.36 81.82,46.36 82.28,45.9 83.47,45.9 84.59,47.02 85.15,47.02 86.31,48.18 88.44,48.18 88.71,47.91 88.71,46.64 v5(88.94,46.41)
  IN4 w0.089: v2(74.23,45.85) 73.95,45.85 v5(73.9,45.9) ; v2(88.48,46.41) v5(88.94,46.41)
  BOTTOM w0.127: v2(88.48,46.41) 88.38,46.41 88.13,46.16 87.56,46.16 86.95,45.55 TP117.1 ; U16.AJ7 v2(74.23,45.85)
SIO_SLP_S3#: length 81.7
  TOP w0.127: v4(116.29,52) 116.29,44.86 v7(117.38,43.77) 118.02,43.13 PR55.1 ; U4.E1 134.32,57.98 v4(134.25,58.04)
  IN1 w0.089: v5(76.92,41.48) 79.11,41.48 82.35,38.24 84.88,38.24 87.44,40.8 87.91,40.8 90.66,43.55 90.66,46.61 94.55,50.5 102.65,50.5 103.31,51.16 108.87,51.16 109.43,51.73 116.02,51.73 v4(116.29,52) 116.66,52.37 120.8,52.37 123.33,54.89 123.69,54.89 124.41,55.61 124.41,55.98 125.33,56.9 125.7,56.9 127.03,58.23 131.16,58.23 131.56,58.63 133.66,58.63 v4(134.25,58.04)
  IN4 w0.089: v5(76.92,41.48) 76.69,41.72 v2(76.06,41.72)
SIO_SLP_S4#: length 153.9
  TOP w0.127: PR66.1 119.37,42.14 v4(119.37,42.65) 121.9,42.65 122.05,42.8 122.05,43.69 122.92,44.55 126.08,44.55 126.78,45.26 126.78,45.5 128.15,46.87 131.79,46.87 131.96,47.05 131.96,48.9 v4(132.24,49.18) 132.24,50.96 132.47,51.19 133.31,51.19 133.88,51.76 133.88,52.72 134.6,53.45 134.98,53.45 U4.N2
  IN1 w0.089: v9(144.99,31.07) 144.59,31.48 144.59,34.52 143.16,35.95 137.86,35.95 136.94,36.86 136.94,37.87 136.64,38.18 136.64,39.02 135.72,39.94 135.72,43.54 134.6,44.66 134.6,48.44 133.87,49.18 v4(132.24,49.18) ; v5(118.86,42.52) 118.98,42.65 v4(119.37,42.65)
  IN2 w0.089: v6(180.68,13.36) 177.94,13.36 175.09,16.21 173.82,16.21 172.04,17.99 172.04,18.24 169.61,20.68 165.59,20.68 162.87,17.96 150.58,17.96 149.26,19.28 149.26,21.37 149.21,21.42 149.21,26.47 149.26,26.52 149.26,28.55 147.58,30.23 145.73,30.23 144.99,30.97 v9(144.99,31.07)
  IN3 w0.089: v2(74.73,45.85) 75.13,45.45 76.54,45.45 76.8,45.71 79.11,45.71 79.38,45.98 81.11,45.98 81.26,46.13 87.15,46.13 87.3,45.98 90.54,45.98 93.3,48.75 101.05,48.75 103.36,46.44 111.41,46.44 115.33,42.52 v5(118.86,42.52)
  BOTTOM w0.127: PR212.1 180.87,13.55 v6(180.68,13.36)
SIO_SLP_S5#: length 111.8
  TOP w0.127: v4(117.81,40.39) 117.31,40.89 117.31,41.94 v7(116.7,42.55) ; D4.2 146.34,61.09 146.34,61.22 v6(146.14,61.42)
  IN1 w0.089: v4(117.81,40.39) 117.81,39.98 v5(115.63,37.8)
  IN3 w0.089: v5(115.63,37.8) 117.69,39.86 120.58,39.86 121.17,39.27 123.66,39.27 124.09,39.7 136.74,39.7 137.43,40.4 142.95,40.4 147.05,44.5 v2(147.33,44.5)
  IN4 w0.089: v5(115.63,37.8) 114.28,36.45 111.95,36.45 110.98,35.49 106.21,35.49 103.85,33.13 96.25,33.13 95.92,32.8 93.46,32.8 92.62,33.63 92.62,36.38 92.21,36.78 81.59,36.78 80.45,37.92 78.83,37.92 77.58,39.17 77.58,41.49 76.51,42.55 76.46,42.55 76.28,42.73 75.6,42.73 75.53,42.66 v2(75.44,42.66)
  BOTTOM w0.127: v6(146.14,61.42) 146.14,58.6 149.69,55.05 149.69,46.86 v2(147.33,44.5) ; U16.AP5 v2(75.44,42.66)
SIO_WAKE_SCI#: length 90.3
  TOP w0.127: v2(75.11,43.64) 75.74,43.01 R131.1 ; v4(138.39,46.18) 138.41,46.16 v6(139,46.16) 139.13,46.16 139.51,46.54 139.51,47.12 139.84,47.45 D16.2
  IN1 w0.089: v5(74.84,43.84) 74.86,43.84 75.07,43.64 v2(75.11,43.64) ; v4(138.39,46.18) 138.35,46.15 138.35,41.52 139.28,40.59 140.27,40.59 v9(142.02,38.84)
  IN2 w0.089: v9(142.02,38.84) 141.67,38.49 136.74,38.49 136.43,38.79 133.08,38.79 132.62,38.33 123.25,38.33 122.97,38.61 117.99,38.61 117.79,38.41 114.74,38.41 114.34,38 110.37,38 109.8,38.57 106.52,38.57 105.57,39.53 105.57,40.06 103.16,42.47 97.14,42.47 95.84,41.18 92.95,41.18 91.83,40.06 88.33,40.06 84.71,43.68 84.71,44.39 84.46,44.63 82.48,44.63 79.57,41.72 77.55,41.72 75.42,43.84 v5(74.84,43.84)
  IN4 w0.089: v5(74.84,43.84) 75.05,43.64 v2(75.11,43.64)
SLP_S0#: length 86.9
  TOP w0.127: v4(136.18,48.34) 136.48,48.65 140.73,48.65 142.02,49.94 PQ2.2
  IN1 w0.089: v4(136.18,48.34) 136.18,45.52 136.81,44.89 v5(136.81,44.96)
  IN3 w0.089: v5(136.81,44.96) 136.81,44.42 135.42,43.03 131.73,43.03 130.1,44.66 115.21,44.66 111.4,48.47 103.78,48.47 v2(102.84,49.41) 101.97,50.27 92.06,50.27 91.27,49.48 90.15,49.48 89.67,49 88.68,49 87.64,50.04 87.18,50.04 86.88,49.74 86.88,49.41 86.71,49.24 84.6,49.24 v2(84.57,49.28)
  BOTTOM w0.089: U16.AF3 76.88,47.71 77.38,48.21 79.08,48.21 79.14,48.27
  BOTTOM w0.127: PR173.1 102.83,56.97 v7(102.83,54.03) 102.84,54.02 v2(102.84,49.41) ; 79.14,48.27 79.28,48.41 80.41,48.41 80.73,48.09 81.49,48.09 82.28,48.87 82.28,49 82.97,49.69 84.18,49.69 84.57,49.31 v2(84.57,49.28)
SLP_S0#_P: length 3.8
  BOTTOM w0.203: PR173.2 103.46,59.06 v7(103.13,59.39) 102.93,59.59 102.93,61.09 103.13,61.29 PU17.2
SLP_SUS: length 4.9
  TOP w0.127: v7(83.02,35.16) 82.96,35.1 R165.2 81.58,35.1 81.44,35.23 Q8.3 80.71,33.84 80.6,33.74 Q9.2
SLP_SUS#: length 183.2
  TOP w0.127: U4.G13 141.44,56.98 v9(141.67,57.21) ; 78.72,35.89 79.59,36.76 v4(79.59,37.16) 79.23,37.52 v7(79.23,37.8) 79.28,37.85 79.28,41.1 79.27,41.11 79.27,41.42 78.5,42.19 78.22,42.19 78.21,42.19 76.31,42.19 76.06,42.44 v4(76.06,42.54)
  IN1 w0.089: v9(149.54,19.92) 149.77,20.15 149.77,25.76 150.17,26.17 150.17,30.05 148.7,31.53 148.7,34.17 143.61,39.26 142.87,39.26 140.57,41.56 139.84,41.56 139.61,41.79 139.61,49.69 139.89,49.97 v9(139.89,50.04) ; v4(76.06,42.54) 76.34,42.27 v5(76.34,42.19) ; v4(79.59,37.16) 79.97,36.78 80.99,36.78 81.5,37.3 85.77,37.3 86.72,38.26 87.67,38.26 88.45,39.04 88.45,39.93 90.85,42.33 91.25,42.33 91.96,43.03 91.96,43.54 92.42,44 92.42,45.14 92.28,45.27 92.28,46.1 95.36,49.18 96.38,49.18 97.14,48.42 102.55,48.42 103.82,49.69 111.84,49.69 v5(112.1,49.95) 112.25,50.09 116.32,50.09 117.31,51.08 121.45,51.08 v9(123.66,53.29)
  IN2 w0.089: v6(182.33,13.36) 181.92,13.77 178.17,13.77 175.47,16.46 173.95,16.46 172.3,18.11 172.3,18.37 169.73,20.93 165.08,20.93 162.62,18.47 150.99,18.47 v9(149.54,19.92) ; v9(141.67,57.21) 142.68,56.19 142.86,56.19 143.65,55.4 143.65,54 143.27,53.62 142.86,53.62 141.87,52.63 141.87,52.02 v9(139.89,50.04) 139.61,49.76 136.28,49.76 136.08,49.97 129.22,49.97 126.47,52.72 124.23,52.72 v9(123.66,53.29)
  IN3 w0.089: v5(112.1,49.95) 112.13,49.92 v2(113.14,49.92)
  IN4 w0.089: v5(76.34,42.19) 76.31,42.19 76.11,42.4 v2(76.11,42.47)
  BOTTOM w0.127: v4(76.06,42.54) 76.06,42.52 v2(76.11,42.47) ; v2(113.14,49.92) 113.14,53.34 113.01,53.47 113.01,55.17 111.03,57.15 104.93,57.15 PR174.1 ; PR213.1 182.52,13.55 v6(182.33,13.36)
SLP_WLAN: length 23.4
  IN3 w0.089: v2(78.42,44.07) 78.42,43.92 78.75,43.59 81.77,43.59 83.18,44.99 87.85,44.99 87.94,45.08 91.73,45.08 91.8,45 93.31,45 v2(93.9,44.4)
  BOTTOM w0.076: v2(78.42,44.07) 78.42,43.99 78.14,43.72 75.45,43.72 75.11,44.05 U16.AM5
  BOTTOM w0.127: v2(93.9,44.4) R332.1 93.99,44.4 95.64,42.75 TP118.1
SM_INTRUDER#: length 11.8
  BOTTOM w0.089: U16.AU6 74.18,40.53 74.18,38.59 74.39,38.37
  BOTTOM w0.127: v7(80.48,33.71) 80.48,33.81 79.46,34.83 R365.2 79.46,35.36 79.05,35.77 76.21,35.77 74.85,37.13 74.85,37.92 74.39,38.37
SM_RCOMP_0: length 2.5
  TOP w0.305: v7(39.48,41.44) 39.57,41.36 R149.2 40.72,41.36 v4(40.84,41.48)
  IN1 w0.305: v5(41.45,41.51) 41.42,41.48 v4(40.84,41.48)
  IN4 w0.305: v5(41.45,41.51) v2(41.45,41.04)
SM_RCOMP_1: length 2.5
  TOP w0.305: v7(39.56,40.11) 39.76,40.32 v4(40.74,40.32)
  IN1 w0.305: v5(41.4,39.97) 41.09,39.97 v4(40.74,40.32)
  IN4 w0.305: v2(41.44,40.37) 41.44,40 v5(41.4,39.97)
SM_RCOMP_2: length 3.1
  TOP w0.305: v7(37.68,41.36) 38.58,41.36 v4(38.59,41.34)
  IN1 w0.305: v4(38.59,41.34) 38.62,41.31 v5(40.31,41.31)
  IN4 w0.305: v5(40.31,41.31) v2(40.74,41.31)
SM_VREF_CA: length 30.6
  TOP w0.508: v6(47.76,43.08) 47.76,41.18 44.18,37.6 v7(44.18,35.62) 44.18,34.46 45.64,33 53.6,33 54.29,32.31 56.52,32.31 56.53,32.31 v6(56.55,32.31)
  IN4 w0.508: v6(56.55,32.31) 56.55,27.68 v6(56.56,27.67)
  BOTTOM w0.508: v6(47.76,43.08) 48,42.85 U16.AP49 ; v6(56.56,27.67) 56.55,27.67 56.51,27.67 56.5,27.67 55.99,27.67 C271.1 55.71,27.52 55.59,27.64 R373.1
SM_VREF_DQ0: length 34.6
  TOP w0.508: v6(46.85,41.89) 40.89,35.93 31.36,35.93 v6(28.76,38.54)
  IN1 w0.508: v6(29.32,29.57) 28.94,29.95 28.94,38.36 v6(28.76,38.54)
  BOTTOM w0.508: U16.AR51 47.16,42.2 v6(46.85,41.89) ; v6(29.32,29.57) 29.3,29.54 29.3,28.94 v7(29.69,28.55) R372.1 30.24,27.64 30.35,27.52 C270.1
SM_VREF_DQ1: length 46.2
  TOP w0.508: v6(63.16,32.38) 62.13,33.41 54.63,33.41 54.02,34.02 46.1,34.02 45.3,34.82 45.3,37.28 48.78,40.76 48.78,43.54 48.22,44.1 v7(47.71,44.1) 47.33,44.1 46.84,43.61 v6(46.84,43.17)
  IN2 w0.508: v6(63.16,32.38) 63.16,30.81 v6(66.33,27.64)
  BOTTOM w0.381: U16.AP51 47.17,42.85 v6(46.84,43.17)
  BOTTOM w0.508: v6(66.33,27.64) 69.33,27.64 69.83,27.14 C272.1 72.85,27.26 R374.1
SMB_CLK_ME1: length 20.9
  TOP w0.127: RP6.1 88.61,45.08 88.47,44.95 88.06,44.95 v6(88,44.89) 87.79,44.68 87.79,44.04 v4(87.77,44.02)
  IN1 w0.089: v5(87.72,43.64) 87.77,43.7 v4(87.77,44.02) 87.77,44.09 87.27,44.59 85.75,44.59 84.73,43.58 82.35,43.58 81.84,43.07 79.45,43.07 78.71,43.81 77.09,43.81 76.84,43.57 76.84,42.04 76.54,41.74 76.54,40.94 v5(76.84,40.64)
  IN4 w0.089: v2(76.7,41.07) 76.7,40.78 v5(76.84,40.64) ; v5(87.72,43.64) v2(87.72,44.02)
  BOTTOM w0.127: v2(87.72,44.02) 87.74,44.05 87.74,44.18 88.02,44.45 88.91,44.45 88.97,44.52 Q28.4
SMB_DATA_ME1: length 21.5
  TOP w0.127: RP6.3 88.61,44.43 88.47,44.57 88.32,44.57 88.17,44.42 v4(88.17,44.02)
  IN1 w0.089: v5(77.3,46.05) 77.3,45.32 77.05,45.06 77.05,44.28 77.18,44.15 78.85,44.15 79.59,43.41 81.7,43.41 82.2,43.92 84.59,43.92 85.61,44.94 87.41,44.94 88.12,44.23 88.12,44.07 v4(88.17,44.02) 88.17,43.7 v5(88.22,43.64)
  IN4 w0.089: v5(88.22,43.64) v2(88.22,44.02) ; v5(77.3,46.05) 76.87,46.05 v2(76.71,46.21)
  BOTTOM w0.127: v2(88.22,44.02) 88.22,43.59 v6(88.15,43.51) 88.15,42.91 88.81,42.24 90,42.24 90.27,42.51 Q28.1
SMBCLK: length 125.4
  TOP w0.127: v9(91.71,42.03) 91.79,42.03 91.85,41.97 RP8.1
  IN2 w0.089: v5(79.03,42.07) 79.03,44.15 79.45,44.57 79.98,44.57 80.85,45.43 85.16,45.43 86.54,44.05 86.54,42.86 88.14,41.27 91.13,41.27 91.48,41.61 91.48,41.79 v9(91.71,42.03) 91.71,42.06 91.53,42.24 91.53,42.33 91.61,42.41 92.48,42.41 92.98,41.9 95.45,41.9 96.97,43.43 103.19,43.43 107.35,39.27 117.69,39.27 117.8,39.39 123.46,39.39 123.8,39.04 132.17,39.04 132.88,39.76 136.59,39.76 137.13,39.21 141.37,39.21 141.84,39.68 143.97,39.68 146.49,42.21 155.29,42.21 155.52,41.98 160.42,41.98 161.17,41.23 176.08,41.23 176.36,41.23 177.35,42.22 177.35,42.65 v5(177.56,42.85)
  IN4 w0.089: v5(79.03,42.07) 78.98,42.12 v2(78.7,42.12) ; v5(177.56,42.85) 177.34,43.07 177.34,43.3 175.3,45.34 174.71,45.34 174.1,45.95 174.1,48.09 173.7,48.49 173.7,49.08 v2(173.49,49.28)
  BOTTOM w0.127: Q26.3 171.78,46.96 171.91,47.09 R316.2 171.91,48.31 172.17,48.57 172.78,48.57 v2(173.49,49.28) ; v2(78.7,42.12) 77.95,42.12 77.56,42.5 U16.AP2
SMBCLK0: length 101.2
  TOP w0.127: v4(136.69,62.2) 136.69,62.52 136.81,62.64 RP2.3 ; PR86.2 126.34,36.68 126.34,36.92 126.21,37.05 v6(126.06,37.05) ; ESD2.6 111.07,17.64 111.24,17.48 111.24,17.07 111.47,16.84 111.6,16.84 v6(111.89,17.13) 112.17,16.84 112.48,16.84 113.12,16.21 113.12,13.81 PR139.2
  IN1 w0.089: v4(136.51,59.48) 136.5,59.48 136.33,59.64 136.33,60.51 136.66,60.84 136.66,62.18 v4(136.69,62.2) 136.67,62.22 136.67,62.47 135.5,63.64 133.16,63.64 132.26,62.74 132.05,62.74 v5(131.82,62.97)
  IN4 w0.089: v2(131.3,62.91) 131.47,62.74 131.6,62.74 v5(131.82,62.97) ; v6(126.06,37.05) 126.32,36.78 126.32,36.51 126.11,36.29 122.96,36.29 119.7,33.04 117.17,33.04 115.85,34.36 113.61,34.36 112.14,32.89 112.14,31.95 111.06,30.87 105.75,30.87 105.03,30.14 105.03,24.7 106.4,23.33 106.4,19.52 107.39,18.53 111.81,18.53 112.42,17.92 112.42,16.99 112.3,16.87 112.14,16.87 v6(111.89,17.13)
  BOTTOM w0.127: v6(126.06,37.05) 126.34,37.33 126.34,40.39 126.73,40.78 126.73,43.45 121.78,48.41 121.78,61.53 123.01,62.76 131.15,62.76 v2(131.3,62.91)
SMBCLK0_B: length 4
  TOP w0.127: v6(113.42,11.54) 113.14,11.82 113.14,12.03 PR139.1
  BOTTOM w0.127: JBAT1.B7 113.7,10.7 113.14,11.26 113.14,11.41 113.27,11.54 v6(113.42,11.54)
SMBCLK0_P: length 3.5
  TOP w0.127: PR86.1 126.22,35.23 126.22,34.85 126.58,34.5 127.56,34.5 127.81,34.25 127.81,33.99 127.75,33.93 PU12.9
SMBCLK1: length 63.2
  TOP w0.127: v4(135.21,62.3) 135.02,62.49 135.02,62.55 135.16,62.69 RP1.3 ; U4.B3 v4(136.01,59.55)
  IN1 w0.089: v4(136.01,59.55) 135.93,59.64 135.93,59.8 135.62,60.1 135.29,60.1 135.21,60.18 135.21,61.17 134.96,61.42 134.96,62.05 v4(135.21,62.3) 135.2,62.3 134.99,62.51 134.99,62.71 134.76,62.95 133.71,62.95 131.95,61.18 131.34,61.18 131.04,60.88 130.07,60.88 129.63,60.43 129.63,59.95 129.14,59.47 126.2,59.47 125.21,58.48 125.01,58.48 121.7,55.17 119.57,55.17 117.98,53.59 116.05,53.59 115.45,52.99 106.83,52.99 106.48,52.64 102.58,52.64 101.7,51.76 93.8,51.76 90.61,48.57 90.05,48.57 89.35,47.87 89.35,44.69 89.45,44.6 89.45,43.73 89.36,43.64 v5(88.99,43.64)
  IN4 w0.089: v5(88.99,43.64) v2(88.99,44.02)
  BOTTOM w0.127: v2(88.99,44.02) 88.97,44.01 Q28.3
SMBCLK3: length 94.5
  TOP w0.127: RP5.3 143.95,52.08 143.81,52.21 143.57,52.21 v9(143.38,52.03)
  IN1 w0.089: 177.23,20.49 177.36,20.46 177.5,20.23 178.71,20.23 178.94,20.46 180.8,20.46 180.89,20.37 v4(180.89,19.99) ; 177.23,20.49 177.26,20.61 177.24,20.66 177.19,20.71 177.04,20.86 177.04,29.4 175.99,30.44 175.99,40.61 176.23,40.84 176.23,42.21 175.71,42.72 175.71,44.04 177.19,45.51 177.19,46.68 v5(177.09,46.77) 177.09,46.79 177.16,46.85 177.16,47.09 176.15,48.1 176.15,55.08 175.78,55.45 175.64,55.45 v9(175.47,55.28) ; 177.23,20.49 v4(176.42,19.98) ; v4(138.51,57.98) 138.39,57.98 138.35,57.94 138.35,57.8 138.57,57.59 139.18,57.59 139.53,57.23 140.04,57.23 140.32,57.23 140.37,57.18 141.25,57.18 141.79,56.65 141.98,56.65 142.25,56.37 142.94,56.37 144.16,55.14 144.16,52.59 143.85,52.28 143.63,52.28 v9(143.38,52.03)
  IN2 w0.089: v9(175.47,55.28) 175.35,55.4 174.71,55.4 173.48,56.63 171.81,56.63 171.34,56.16 165.52,56.16 164.25,54.89 146.85,54.89 144.13,52.18 143.53,52.18 v9(143.38,52.03)
  IN4 w0.089: v5(177.09,46.77) 178.14,45.73 178.31,45.73 178.68,45.36 178.68,44.46 v2(179.06,44.07)
  BOTTOM w0.127: Q27.3 179.14,45.02 178.95,44.84 178.95,44.18 v2(179.06,44.07)
SMBCLK3_Q: length 210.5
  TOP w0.127: v9(43.22,43.39) 43.1,43.27 42.7,43.27 42.25,42.83 42.25,40.12 39.65,37.52 32.3,37.52 27.5,42.32 26.41,42.32 v7(25.97,42.77) 25.6,42.4 25.53,42.47 20.04,42.47 19.26,41.69 19.11,41.69 19.05,41.75 U8.10 ; RP14.2 176.38,16.53 176.52,16.4 178.46,16.4 181.49,19.44 181.49,20.17 181.23,20.44 180.56,20.44 v9(180.11,19.99) 180.1,19.98 Q16.4
  IN1 w0.089: v9(132.47,33.99) 132.3,33.82 132.03,33.82 131.71,33.51 130.39,33.51 127.58,36.31 120.44,36.31 120.22,36.09 116.2,36.09 115.4,35.29 115.4,32.85 115.1,32.54 109.75,32.54 109.09,31.88 105.29,31.88 104.14,33.04 100.53,33.04 100.02,32.52 99.33,32.52 v9(99.18,32.67)
  IN2 w0.089: v9(132.47,33.99) 132.64,33.82 132.92,33.82 133.64,33.1 133.64,31.86 134.24,31.26 141.73,31.26 145.26,34.79 150.34,34.79 150.92,35.37 151.71,35.37 152.25,34.84 153.34,34.84 154.05,34.13 155.39,34.13 155.52,34.26 155.52,34.79 158.21,37.48 164.77,37.48 165.73,36.52 165.73,35.3 165.03,34.6 165.03,34.25 165.4,33.88 167.89,33.88 178.54,23.23 179.6,23.23 180.93,21.9 180.93,20.78 180.61,20.46 180.2,20.46 180.11,20.37 v9(180.11,19.99) ; v9(99.18,32.67) 99.01,32.5 95.72,32.5 95.23,32.01 84.49,32.01 80.35,36.15 77.46,36.15 77.16,36.44 77.16,37.54 76.57,38.13 75.7,38.13 73.15,40.68 71.98,40.68 68.51,44.15 67.07,44.15 65.9,45.32 58.99,45.32 58.44,45.86 55.56,45.86 54.99,45.29 53.51,45.29 52.54,44.32 46.56,44.32 45.54,43.31 43.3,43.31 v9(43.22,43.39)
SMBCLK3_R: length 38.9
  IN4 w0.089: v2(175.02,46.63) 175.16,46.49 175.43,46.49 177.25,44.67 177.25,44.51 177.9,43.86 178.08,43.86 v2(178.26,44.04) 178.53,43.78 179.19,43.78 179.44,44.03 179.44,46.18 179.19,46.42 179.19,46.88 179.53,47.22 181.11,47.22 184.12,44.21 192.02,44.21 192.81,45 192.81,47.48 193.87,48.54 193.87,50.36 194.43,50.92 194.43,51.15 v2(194.35,51.23)
  BOTTOM w0.127: Q27.4 178.38,45.02 178.5,44.91 178.5,44.29 R333.1 ; v2(175.02,46.63) RP32.2 174.72,47.09 v6(174.1,47.71) 173.85,47.96 R316.1 172.46,47.73 172.46,47.07 172.57,46.96 Q26.4 ; J1.17 194.35,51.61 194.42,51.54 194.42,51.3 v2(194.35,51.23)
