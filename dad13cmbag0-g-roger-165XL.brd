# Allegro board dad13cmbag0-g-roger-165XL.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
USB_OC1#: length 103.3
  IN1 w0.089: v5(72.48,42.12) 71.72,42.12 v9(70.43,40.82) ; v9(49.93,20.11) 49.32,20.11 47.83,21.59 22.46,21.59 15.15,28.91 13.95,28.91 13.17,29.7 13.17,30.61 13.62,31.07 v6(14.06,31.07)
  IN2 w0.089: v9(70.43,40.82) 70.06,41.19 68.15,41.19 62.19,35.23 62.19,30.54 51.76,20.11 v9(49.93,20.11)
  IN4 w0.089: v2(72.86,42.12) v5(72.48,42.12)
  BOTTOM w0.089: 75.48,41.99 74.16,41.99 73.84,42.31 73.46,42.31 73.27,42.12 v2(72.86,42.12)
  BOTTOM w0.127: CN3.17 14.9,32.28 14.89,32.28 14.63,32.01 14.63,31.64 v6(14.06,31.07) ; R343.1 90.76,41.86 89.74,41.86 R342.1 88.73,41.36 88.48,41.61 TP119.1 87.97,41.99 87.49,42.47 87.49,43.64 86.32,44.81 81.8,44.81 79.08,42.09 79.08,41.86 78.93,41.72 U16.AT1 77.61,42.12 75.61,42.12 75.48,41.99
USB_OC2#: length 11.5
  BOTTOM w0.076: U16.AH2 77.67,45.95 78.29,45.95 78.52,45.72 78.8,45.72
  BOTTOM w0.127: TP107.1 86.51,48.15 83.22,48.15 83.01,47.93 R317.1 82.64,47.71 82.38,47.45 82.38,47.07 81.58,46.27 79.93,46.27 79.38,45.72 78.8,45.72
USBP0+: length 170.3
  TOP w0.127: v6(196.48,44.53) 196.48,44.63 196.66,44.81 197.06,44.81 197.24,44.99 197.5,44.99 197.65,44.84 U7.3
  IN4 w0.114: v6(196.48,44.53) 196.48,44.63 196.62,44.77 196.9,44.77 197.18,44.49 197.18,43.45 196.64,42.92 196.64,42.31 193.42,39.09 193.42,32.4 194.21,31.61 194.21,24.02 193.25,23.07 185.73,23.07 182.64,19.97 173.39,19.97 171.93,21.43 169.01,21.43 168.16,22.28 168.16,24.16 167.55,24.77 166.74,24.77 165.69,25.81 165.69,32.85 163.41,35.13 162.75,35.13 162.14,35.74 162.14,36.91 161.38,37.67 158.64,37.67 154.66,41.65 151.2,41.65 150.45,42.4 145.15,42.4 144.92,42.63 143.16,42.63 141.87,41.33 136.69,41.33 136.37,41.65 131.44,41.65 130.86,42.23 123.42,42.23 123.27,42.38 120.51,42.38 120.24,42.12 114.37,42.12 112.52,40.26 108.06,40.26 106.64,41.69 106.64,42.91 105.51,44.04 100.15,44.04 98.6,42.49 90.5,42.49 89.75,43.24 87.39,43.24 87.08,43.54 87.08,44.02 86.46,44.65 81.09,44.65 80.87,44.86 78.07,44.86 77.85,44.64 75.07,44.64 74.98,44.54 74.47,44.54 74.13,44.2 74.13,43.87 73.92,43.67 73.54,43.67 73.44,43.77 73.44,43.91 73.49,43.96 v2(73.71,43.96)
USBP0+_L: length 12.7
  TOP w0.127: v4(205.77,44.09) 205.48,44.09 205.14,44.43 205.14,44.76 205.01,44.89 204.78,44.89 204.66,44.76 EL1.3
  IN1 w0.114: v4(205.77,44.09) 205.48,44.38 204.99,44.38 204.37,45 204.37,46.02 205.23,46.88 209.27,46.88 209.86,47.48 210.65,47.48 210.87,47.7 CN2.3
USBP0+_R: length 1.7
  TOP w0.127: U7.10 201.94,44.84 202.04,44.94 202.5,44.94 202.67,44.76 EL1.4
USBP0-: length 170.4
  TOP w0.127: U7.2 197.67,45.34 197.58,45.25 197.13,45.25 196.95,45.08 196.59,45.08 v6(196.48,45.19)
  IN4 w0.114: v2(73.71,43.31) 73.72,43.32 74.07,43.32 74.47,43.73 74.47,44.06 74.61,44.2 75.12,44.2 75.21,44.3 77.99,44.3 78.22,44.52 80.73,44.52 80.94,44.3 86.32,44.3 86.74,43.88 86.74,43.4 87.24,42.89 89.61,42.89 90.36,42.14 98.74,42.14 100.29,43.69 105.37,43.69 106.3,42.76 106.3,41.54 107.92,39.92 112.66,39.92 114.51,41.77 120.38,41.77 120.65,42.04 123.12,42.04 123.28,41.89 130.72,41.89 131.3,41.3 136.23,41.3 136.55,40.99 142.01,40.99 143.31,42.28 144.77,42.28 145,42.05 150.31,42.05 151.06,41.3 154.52,41.3 158.49,37.33 161.23,37.33 161.8,36.77 161.8,35.6 162.61,34.79 163.27,34.79 165.35,32.7 165.35,25.67 166.59,24.43 167.41,24.43 167.82,24.02 167.82,22.14 168.87,21.09 171.79,21.09 173.25,19.63 182.78,19.63 185.88,22.72 193.39,22.72 194.55,23.88 194.55,31.75 193.76,32.54 193.76,38.94 196.99,42.17 196.99,42.78 197.52,43.31 197.52,44.63 197.04,45.11 196.56,45.11 v6(196.48,45.19)
USBP0-_L: length 12.7
  TOP w0.127: EL1.2 204.69,45.31 204.85,45.15 205,45.15 205.14,45.29 205.14,45.8 205.33,45.99 v4(205.77,45.99)
  IN1 w0.114: CN2.2 210.86,45.7 210.68,45.88 209.84,45.88 209.18,46.54 205.37,46.54 204.71,45.88 204.71,45.14 205.13,44.72 205.61,44.72 205.77,44.88 v4(205.77,45.99)
USBP0-_R: length 1.7
  TOP w0.127: U7.11 201.92,45.34 202.05,45.2 202.59,45.2 202.7,45.31 EL1.1
USBP1+: length 70.4
  IN2 w0.114: v5(73.92,41.56) 73.95,41.58 73.95,41.84 73.85,41.94 73.47,41.94 72.91,41.38 72.17,41.38 68.77,44.78 67.42,44.78 66.21,45.99 60.29,45.99 59.91,46.37 50.62,46.37 49.38,45.13 38.18,45.13 36.65,43.6 31.77,43.6 29.34,41.17 25.83,41.17 25.07,40.4 15.14,40.4 14.26,39.53 14.26,38.71 14.42,38.55 14.58,38.55 14.85,38.82 v6(14.85,38.89)
  IN4 w0.114: v2(74.28,41.53) 74.2,41.46 74.03,41.46 v5(73.92,41.56)
  BOTTOM w0.127: CN3.35 13.4,37.76 13.52,37.88 13.52,38.12 13.87,38.47 14.5,38.47 14.85,38.82 v6(14.85,38.89) ; U16.AT7 v2(74.28,41.53)
USBP1-: length 70.6
  IN2 w0.114: v6(14.85,38.21) 14.28,38.21 13.92,38.57 13.92,39.67 14.99,40.75 24.93,40.75 25.69,41.51 29.19,41.51 31.63,43.94 36.51,43.94 38.03,45.47 49.24,45.47 50.48,46.72 60.06,46.72 60.44,46.33 66.35,46.33 67.56,45.13 68.91,45.13 72.31,41.72 72.77,41.72 73.33,42.28 73.99,42.28 v5(74.28,41.99)
  IN4 w0.114: v5(74.28,41.99) 74.28,42.33 v2(74.28,42.34)
  BOTTOM w0.127: v6(14.85,38.21) 13.98,38.21 13.78,38.01 13.78,37.88 13.9,37.76 CN3.36
USBP2+: length 105.1
  IN4 w0.114: v2(73.71,42.66) 74.35,43.3 75.27,43.3 75.52,43.55 76.63,43.55 76.99,43.92 78.07,43.92 78.24,43.74 82.15,43.74 82.34,43.93 85.47,43.93 87.77,41.64 98.97,41.64 100.5,43.17 103.89,43.17 105.44,41.62 105.51,41.62 107.71,39.43 112.99,39.43 114.83,41.27 120.8,41.27 121.05,41.52 122.88,41.52 123.05,41.36 130.54,41.36 131.09,40.81 136.01,40.81 136.56,40.26 142.71,40.26 147.38,35.59 148.6,35.59 149.43,34.76 149.43,29.94 150.53,28.83 150.53,24.77 148.8,23.04 148.8,21.72 149.17,21.36 149.17,18.13 147.8,16.76 147.13,16.76 v2(147.11,16.73)
  BOTTOM w0.127: EL9.4 146.45,16.78 146.56,16.88 146.96,16.88 v2(147.11,16.73)
USBP2+_R: length 15.9
  IN4 w0.114: v2(142.62,10.82) 142.62,11.02 142.73,11.13 143.19,11.13 143.45,11.39 143.45,12.04 142.29,13.2 141.51,13.2 140.74,13.97 140.74,14.11 140.85,14.23 140.95,14.23 v2(140.95,14.23)
  BOTTOM w0.127: v2(140.95,14.23) 140.95,14.23 140.83,14.23 140.7,14.36 140.7,14.54 v7(141.2,15.04) 140.66,15.58 140.66,15.67 140.81,15.82 141.24,15.82 141.7,16.28 141.7,17.25 141.87,17.41 142.02,17.41 142.79,16.64 ESD3.3 143.52,16.64 143.72,16.84 143.85,16.97 144.15,16.97 144.34,16.78 EL9.3 ; JP2.4 143.85,10.79 143.56,11.08 142.73,11.08 142.62,10.97 v2(142.62,10.82)
USBP2-: length 105.1
  IN4 w0.114: v2(73.71,42.01) 73.71,42.18 74.49,42.96 75.41,42.96 75.66,43.21 76.77,43.21 77.14,43.58 77.92,43.58 78.1,43.4 82.29,43.4 82.48,43.59 85.33,43.59 87.62,41.29 99.11,41.29 100.64,42.83 103.74,42.83 105.29,41.28 105.37,41.28 107.56,39.08 113.13,39.08 114.97,40.92 120.94,40.92 121.19,41.18 122.74,41.18 122.91,41.01 130.4,41.01 130.94,40.47 135.87,40.47 136.42,39.92 142.57,39.92 147.24,35.25 148.46,35.25 149.08,34.62 149.08,29.8 150.19,28.69 150.19,24.91 148.46,23.18 148.46,21.58 148.83,21.21 148.83,18.27 147.66,17.1 146.92,17.1 146.85,17.17 146.85,17.35 146.92,17.43 v2(147.11,17.43)
  BOTTOM w0.127: EL9.1 146.45,17.33 146.63,17.15 147.05,17.15 147.11,17.21 v2(147.11,17.43)
USBP2-_R: length 15.8
  IN4 w0.114: v2(142.62,11.58) 142.73,11.47 143.05,11.47 143.11,11.53 143.11,11.9 142.15,12.86 141.37,12.86 140.4,13.83 140.4,14.18 v2(140.35,14.23)
  BOTTOM w0.127: EL9.2 144.34,17.33 144.25,17.24 144.07,17.24 143.7,17.61 143.7,18.22 143.38,18.54 ESD3.1 142.83,18.54 141.97,17.67 141.75,17.67 141.44,17.36 141.44,16.39 141.13,16.08 140.7,16.08 140.4,15.78 140.4,15.5 v7(139.93,15.04) 140.43,14.54 140.43,14.31 v2(140.35,14.23) ; v2(142.62,11.58) 142.86,11.34 143.61,11.34 143.85,11.59 JP2.5
USBP4+: length 177
  IN4 w0.114: v2(69.44,44.61) 69.44,44.54 69.66,44.33 69.85,44.33 69.96,44.44 69.96,45.34 70.42,45.8 71.61,45.8 71.95,46.14 72.99,46.14 73.31,46.46 73.48,46.46 75.33,46.45 75.38,46.51 75.83,46.51 76.03,46.72 79.18,46.72 79.36,46.54 80.83,46.54 81.13,46.84 82.37,46.84 82.89,46.32 87.17,46.32 87.36,46.13 88.02,46.13 88.35,45.8 91.17,45.8 91.5,46.13 95.95,46.13 96.91,45.17 98.84,45.17 99.38,45.71 106.4,45.71 108.34,43.77 108.34,42.37 108.78,41.94 111.72,41.94 114.04,44.26 131.24,44.26 131.92,43.58 141.65,43.58 142.55,44.48 146.65,44.48 146.94,44.19 151.43,44.19 152,43.62 156.8,43.62 160.5,39.92 161.21,39.92 161.73,39.4 163.56,39.4 166.2,36.76 166.2,34.09 166.58,33.71 166.58,26.45 166.94,26.09 167.47,26.09 169,24.57 169,23.19 169.69,22.5 172.37,22.5 173.77,21.1 182.52,21.1 185.34,23.92 190.07,23.92 190.43,24.29 190.43,29.93 192.21,31.7 192.21,37.46 191.84,37.83 191.63,37.83 191.55,37.75 v2(191.55,37.65)
  BOTTOM w0.127: EL2.2 183.59,48.1 183.73,47.95 183.73,47.8 v7(183.23,47.3) 183.73,46.8 183.73,44.15 190.01,37.87 191.4,37.87 191.55,37.72 v2(191.55,37.65) ; v2(69.44,44.61) 69.44,44.41 69.56,44.3 69.76,44.3 69.87,44.42 U16.AL15
USBP4+_L: length 3
  BOTTOM w0.127: EL2.1 183.59,50.28 183.72,50.41 183.72,50.79 184.04,51.11 184.31,51.11 184.47,51.27 184.47,51.4 184.35,51.52 J1.37
USBP4-: length 177
  IN4 w0.114: v2(69.44,43.96) 69.6,44.12 69.93,44.12 70.16,44.36 70.16,45.26 70.5,45.6 71.7,45.6 72.03,45.93 73.07,45.93 73.39,46.25 75.41,46.25 75.47,46.31 75.91,46.31 76.12,46.51 79.1,46.51 79.41,46.19 80.97,46.19 81.28,46.5 82.23,46.5 82.75,45.98 87.03,45.98 87.22,45.79 87.88,45.79 88.21,45.46 91.32,45.46 91.65,45.79 95.8,45.79 96.77,44.82 98.98,44.82 99.53,45.37 106.26,45.37 108,43.63 108,42.23 108.63,41.6 111.86,41.6 114.18,43.92 131.1,43.92 131.78,43.24 141.79,43.24 142.69,44.14 146.5,44.14 146.8,43.84 151.29,43.84 151.86,43.27 156.66,43.27 160.36,39.58 161.07,39.58 161.59,39.06 163.42,39.06 165.86,36.62 165.86,33.95 166.24,33.57 166.24,26.3 166.8,25.75 167.33,25.75 168.65,24.42 168.65,23.05 169.55,22.15 172.23,22.15 173.63,20.76 182.66,20.76 185.48,23.58 190.21,23.58 190.78,24.14 190.78,29.78 192.55,31.56 192.55,37.6 191.99,38.17 191.6,38.17 v2(191.55,38.21)
  BOTTOM w0.127: v2(69.44,43.96) 69.57,44.09 69.75,44.09 U16.AM15 ; EL2.3 184.14,48.1 183.99,47.95 183.99,47.8 v7(184.5,47.3) 183.99,46.8 183.99,44.26 190.12,38.14 191.48,38.14 v2(191.55,38.21)
USBP4-_L: length 3
  BOTTOM w0.127: J1.36 184.85,51.51 184.74,51.4 184.74,51.16 184.42,50.84 184.15,50.84 183.98,50.68 183.98,50.45 184.14,50.3 EL2.4
USBP5+: length 109.2
  IN4 w0.114: v2(163.89,37.04) 163.94,37.09 163.94,37.34 163.12,38.17 158.92,38.17 154.93,42.16 151.51,42.16 150.67,42.99 146.3,42.99 145.99,43.3 143.08,43.3 142.16,42.38 131.44,42.38 130.74,43.08 114.6,43.08 112.28,40.76 108.28,40.76 107.16,41.88 107.16,43.17 105.8,44.53 99.91,44.53 98.66,43.29 96.5,43.29 96.14,43.65 91.13,43.65 90.16,44.62 87.19,44.62 86.67,45.14 82.28,45.14 81.9,45.52 81.54,45.52 81.38,45.36 79.58,45.36 79.45,45.23 78.46,45.23 78.34,45.34 72.94,45.34 71.52,43.92 70.72,43.92 v2(70.44,43.64)
  BOTTOM w0.127: EL8.4 169.24,36.97 169.05,36.78 168.36,36.78 168.22,36.64 166.21,36.64 165.28,37.58 164.62,37.58 164.29,37.58 164.01,37.3 164.01,37.15 v2(163.89,37.04)
USBP5+_L: length 2.2
  BOTTOM w0.127: EL8.3 171.3,36.97 171.51,36.77 171.99,36.77 172.12,36.9 CN4.3
USBP5-: length 109.2
  IN4 w0.114: v2(164.35,37.01) 164.28,37.08 164.28,37.48 163.26,38.51 159.06,38.51 155.08,42.5 151.65,42.5 150.81,43.34 146.44,43.34 146.14,43.64 142.93,43.64 142.02,42.73 131.58,42.73 130.88,43.43 114.46,43.43 112.14,41.1 108.42,41.1 107.5,42.02 107.5,43.31 105.94,44.87 99.77,44.87 98.52,43.63 96.65,43.63 96.28,44 91.27,44 90.31,44.96 87.34,44.96 86.81,45.48 82.42,45.48 82.04,45.86 81.4,45.86 81.24,45.7 79.44,45.7 79.31,45.57 78.46,45.57 78.43,45.55 72.86,45.55 71.43,44.12 70.6,44.12 v2(70.44,44.29)
  BOTTOM w0.127: v2(164.35,37.01) 164.27,37.09 164.27,37.19 164.4,37.32 164.51,37.32 164.51,37.32 165.16,37.32 166.1,36.38 168.33,36.38 168.46,36.5 169.17,36.5 169.26,36.42 EL8.1
USBP5-_L: length 2.2
  BOTTOM w0.127: EL8.2 171.31,36.42 171.39,36.5 172.02,36.5 172.12,36.4 CN4.5
USBPLLMON_N: length 5.3
  TOP w0.127: v6(72.95,42.72) 72.95,41.57 R148.1 71.98,41.61 71.13,41.61 v7(70.67,42.07)
  BOTTOM w0.127: v6(72.95,42.72) 72.96,42.73 72.96,43.15 72.48,43.64 U16.AN10
USBPLLMON_P: length 2.7
  TOP w0.127: R140.1 72.48,43.07 v6(72.78,43.36) 72.86,43.44 v6(72.86,44.01)
  BOTTOM w0.127: v6(72.86,44.01) 72.58,44.29 U16.AM10
VCHGR_ACDET: length 6
  TOP w0.127: PR88.1 PC69.1 ; PC69.1 PR89.2 131.37,35.5 131.89,36.02 PQ10.3 ; PC69.1 130.01,34.55 v7(129.96,34.5) 129.88,34.5 129.25,33.87 PU12.6
VCHGR_ACDRV: length 25
  TOP w0.127: v7(120.61,18.27) v4(120.61,19.38)
  TOP w0.254: PU12.4 130.48,32.18 130.85,32.54 133.11,32.54 v4(133.44,32.21)
  IN1 w0.254: v4(120.61,19.38) 121.09,19.86 121.09,20.48 122.77,22.15 123.73,22.15 129.49,27.92 131.94,27.92 133.44,29.42 v4(133.44,32.21)
VCHGR_ACN: length 15.3
  TOP w0.127: PU12.1 130.45,30.68 130.74,30.38 130.74,29.82 v6(131.07,29.49) 131.37,29.79 PC87.2 132.42,29.79 132.54,29.67 v4(133.05,29.67)
  IN1 w0.089: v4(133.05,29.67) 132.67,30.05 132.52,30.05 131.94,29.47 131.4,29.47 131.25,29.32 131.25,29.21 v5(131.4,29.06)
  IN4 w0.089: v5(131.4,29.06) 131.2,28.86 131.2,28.11 127.8,24.71 127.8,22.66 v2(128.33,22.13)
VCHGR_ACP: length 15
  TOP w0.127: v4(133.05,30.69) 132.54,30.69 132.42,30.57 PC87.1 131.27,30.57 v6(131.07,30.76) 130.79,30.76 130.38,31.18 PU12.2
  IN1 w0.089: v4(133.05,30.69) 132.67,30.31 132.47,30.31 131.84,29.67 131.28,29.67 131,29.39 131,29.27 v5(130.77,29.04)
  IN4 w0.089: v2(127.06,22.13) 127.61,22.67 127.61,24.79 130.97,28.16 130.97,28.83 v5(130.77,29.04)
VCHGR_BST:
  vias: v6(127.39,28.81)
VCHGR_CMSRC: length 2.3
  TOP w0.254: PR105.2 131.68,31.83 131.48,32.03 v6(131.07,32.03) 130.97,32.03 130.62,31.68 PU12.3
VCHGR_DH: length 14.2
  TOP w0.203: TP47.1 129.65,16.64 v6(129.35,16.34)
  IN3 w0.508: v6(129.35,16.34) 128.61,17.07 128.61,25.91 128.03,26.5 v6(128.03,28.63)
VCHGR_DL: length 11.2
  TOP w0.254: TP46.1 126.15,20.9 v6(125.78,20.53)
  IN3 w0.635: v6(126.58,30.05) 127.09,29.54 127.09,24.46 125.94,23.32 125.94,20.69 v6(125.78,20.53)
VCHGR_LX: length 20.3
  TOP w0.127: v7(129.96,13.47) 130.87,13.47 130.93,13.53
  TOP w0.508: PC122.1 v6(130.93,13.49)
  IN3 w0.508: v6(128.76,28.63) 128.76,27.64 131.02,25.38 131.02,17.48 132.75,15.75 132.75,14.08 132.17,13.49 v6(130.93,13.49)
VCHGR_SRN: length 29.1
  TOP w0.127: PU12.12 125.84,32.18 v6(125.68,32.33) 125.6,32.25 124.88,32.25 PC83.2 123.95,30.65 123.86,30.56 PC82.1
  IN4 w0.089: v6(125.68,32.33) 126.12,31.9 126.12,31.22 125.23,30.33 125.23,30 125.54,29.69 125.54,28.15 125,27.61 122.97,27.61 120.02,24.67 120.02,14.99 120.81,14.21 122.29,14.21 v2(122.39,14.3)
  BOTTOM w0.127: v2(122.39,14.3) 122.56,14.48 PR211.2P
VCHGR_SRP: length 27.6
  TOP w0.127: PU12.13 125.69,31.68 v6(125.69,31.68) 125.09,31.68 PC83.1 124.73,30.58 124.88,30.43 PC85.1
  IN4 w0.089: v6(125.69,31.68) 125.92,31.45 125.92,31.31 125.03,30.42 125.03,29.93 125.35,29.61 125.35,28.24 124.92,27.81 122.89,27.81 120.09,25.01 119.82,24.75 119.82,14.9 120.71,14.01 122.3,14.01 v2(122.39,13.92)
  BOTTOM w0.127: PR211.1P 122.56,13.75 v2(122.39,13.92)
VCHGR_VCC:
  vias: v7(129.75,28.83)
VCORE_AGND: length 13.2
  TOP w0.381: PR15.2 18.37,60.91 v6(18.32,60.86) ; v6(18.37,59.11) 18.88,58.6 PR20.2 ; PR25.2 v6(18.37,55.2) ; SJ1.2 v6(26.27,59.16) ; v6(18.32,56.37) 18.35,56.37 18.37,56.34 PR22.2
  BOTTOM w0.127: v6(18.37,55.2) 18.21,55.2 v7(17.71,54.7)
  BOTTOM w0.178: PU18.19 23.62,59.99 v6(23.56,60.05) ; v6(25,60.02) 25,59.95 24.82,59.76 PU18.22
  BOTTOM w0.381: PC153.2 PR169.2 19.18,60.86 v6(18.32,60.86) ; PC162.2 25.88,51.39 v6(25.79,51.39) ; v6(18.37,59.11) 18.73,58.75 PC154.2 ; v6(18.37,55.2) 18.88,54.69 PR182.2 ; PR187.2 v6(24.47,51.39)
  BOTTOM w0.508: PC155.2 29.31,58.75 v6(29.8,58.26)
VR_SVID_ALERT#: length 8.1
  IN4 w0.089: v2(29.33,54.31) 29.6,54.58 33.4,54.58 33.76,54.94 34.05,54.94 v2(34.25,54.74)
  BOTTOM w0.127: v2(34.25,54.74) 34.25,54.57 R284.2 R288.2 33.11,53.43 R289.2
VR_SVID_CLK: length 11.1
  IN4 w0.089: v2(37.09,54.26) 35.81,55.55 33.44,55.55 33.11,55.21 29.56,55.21 v2(29.32,55.45)
  BOTTOM w0.127: U16.N63 39.33,54.59 38.9,54.59 38.39,54.08 37.27,54.08 v2(37.09,54.26)
VR_SVID_DATA: length 17.5
  IN4 w0.089: v2(35.85,54.46) 35.74,54.36 34.5,54.36 34.05,53.91 33.11,53.91 32.27,53.07 27.93,53.07 v2(27.01,52.15)
  BOTTOM w0.127: U16.L63 38.83,55.28 38.26,54.72 36.92,54.72 36.66,54.46 v2(35.85,54.46) 35.85,54.28 35.7,54.13 35.7,53.21 R290.2 35.02,52.53 R293.2 ; PR189.2 27.15,52.01 v2(27.01,52.15)
WLAN_DX_WAKE#: length 53.9
  TOP w0.127: v7(167.04,31.45) 168.07,32.47 R187.1 168.62,32.86 v4(168.62,33.51) ; U4.N7 v4(138.01,53.29)
  IN1 w0.089: v5(137.86,52.38) 138.01,52.53 v4(138.01,53.29) ; v4(168.62,33.51) 169.25,33.51 170.44,34.7 170.44,43.96 v5(169.92,44.48)
  IN3 w0.089: v5(169.92,44.48) 167.39,44.48 165.95,45.93 165.95,48.87 163.92,50.91 159.9,50.91 159.55,51.26 149.36,51.26 149.23,51.13 144.65,51.13 143.41,52.37 137.87,52.37 v5(137.86,52.38)
WLAN_ON/OFF#: length 141.7
  TOP w0.127: v4(74.76,41.61) TP36.1
  IN1 w0.089: v5(75.68,41.45) 74.92,41.45 v4(74.76,41.61) ; v9(173.82,40.29) 173.82,33.23 174.97,32.08 174.97,29.48 174.14,28.66 174.14,25.04 174.76,24.41 174.76,20.65 176.24,19.18 176.54,19.18 177.12,19.77 179.41,19.77 180.05,19.13 183.78,19.13 v4(184.26,18.65)
  IN2 w0.089: v9(173.82,40.29) 173.49,40.62 160.13,40.62 159.37,41.38 155.31,41.38 155.05,41.64 147.63,41.64 146.36,40.37 145.68,40.37 143.44,38.13 136.43,38.13 136.26,38.31 133.31,38.31 132.98,37.98 123.94,37.98 123.61,37.65 121.54,37.65 120.96,38.23 118.63,38.23 117.61,37.22 114.54,37.22 114.11,37.65 110.22,37.65 109.64,38.23 106.36,38.23 105.22,39.37 105.22,39.88 104.62,40.48 104.04,40.48 102.53,41.99 97.44,41.99 96.25,40.8 93.43,40.8 92.34,39.7 87.01,39.7 86.25,38.94 85.53,38.94 84.8,38.21 82.1,38.21 80.02,40.29 75.55,40.29 75.32,40.52 75.32,40.9 75.68,41.25 v5(75.68,41.45)
  IN4 w0.089: v2(75.11,41.69) 75.44,41.69 v5(75.68,41.45)
WLAN_ON/OFF#_R: length 5.5
  TOP w0.127: v6(182.05,23.12) 181.77,22.84 v6(181.77,22.46) 182.18,22.05 R216.1 183.6,21.15 Q18.3
  BOTTOM w0.127: CN4.56 181.52,23.65 v6(182.05,23.12)
WRST#: length 10.6
  TOP w0.203: PQ1.3 130.75,57.98 130.9,58.12 R39.2 ; D6.2 129.5,57.74 130.11,58.35 130.26,58.35 130.66,58.75 R39.2 ; R39.2 C39.1 132.25,58.41 132.25,58.03 v7(132.93,57.36) 133.39,56.9 133.39,55.63 134.04,54.98 U4.L1
XCKPLL_MON_DN: length 2.3
  TOP w0.127: v4(66.38,54.44) 66.38,54.39 TP16.1
  IN1 w0.089: v5(66.1,54.67) 66.33,54.44 v4(66.38,54.44)
  IN3 w0.089: v5(66.1,54.67) 66.36,54.93 v2(66.36,56.01)
XCKPLL_MON_DP: length 3
  TOP w0.127: v4(64.5,54.11) 64.52,54.13 TP15.1
  IN1 w0.089: v4(64.5,54.11) 64.56,54.11 64.62,54.18 65.13,54.18 v5(65.34,54.39)
  IN4 w0.089: v2(65.74,54.37) 65.36,54.37 v5(65.34,54.39)
  BOTTOM w0.127: v2(65.74,54.37) 66.33,54.96 U16.M21
XDP_BPM0_R: length 9.1
  BOTTOM w0.127: U16.J60 41.01,56.42 38.64,56.42 37.7,57.36 36.74,57.36 36.56,57.18 35.67,57.18 35.39,56.9 33.41,56.9 TP76.1
XDP_BPM1_R: length 10.6
  BOTTOM w0.089: 38.73,57.5 38.98,57.24 41.01,57.24 v2(41.34,57.57)
  BOTTOM w0.127: 38.73,57.5 38.11,58.12 36.42,58.12 36.26,57.95 34.89,57.95 34.27,57.33 32.57,57.33 TP75.1
XDP_BPM2_R: length 11.6
  IN4 w0.089: v2(30.44,60.79) 31.18,60.05 32.09,60.05 33.64,58.5 38.06,58.5 38.67,57.89 40.35,57.89 40.67,57.57 v2(40.69,57.57)
XDP_BPM3_R: length 9.2
  IN4 w0.089: v2(40.04,57.53) 38.24,57.53 37.68,58.09 33.36,58.09 v2(31.73,59.72)
XDP_BPM4_R: length 5.2
  TOP w0.127: v4(39.2,55.71) 38.82,55.71 TP8.1
  IN1 w0.089: v4(39.2,55.71) 40.95,55.71 41.51,56.26 41.51,56.56 v5(41.52,56.57)
  IN4 w0.089: v5(41.52,56.57) 41.52,56.57 41.76,56.33 v2(41.82,56.33)
  BOTTOM w0.127: U16.K59 41.92,56.18 v2(41.82,56.33)
XDP_BPM5_R: length 8
  BOTTOM w0.127: U16.H63 39.26,57.53 38.29,58.5 36.27,58.5 36.1,58.34 34.73,58.34 34.11,57.71 33.51,57.71 33.03,58.2 TP72.1
XDP_BPM6_R: length 13.2
  IN3 w0.089: v2(30.57,54.03) 30.57,54.09 30.87,54.39 31.85,54.39 31.95,54.29 31.95,53.64 32.62,52.96 38.23,52.96 v2(41.34,56.07)
XDP_BPM7_R: length 1.7
  IN1 w0.089: v5(40.29,56.96) 40.29,56.92 39.96,56.6 v4(39.2,56.6)
  IN4 w0.089: v2(40.69,56.74) 40.51,56.74 v5(40.29,56.96)
XDP_PRDY_N: length 5.4
  BOTTOM w0.089: U16.J62 39.75,57.07 38.58,57.07 38.48,57.17
  BOTTOM w0.127: 38.48,57.17 37.91,57.74 36.58,57.74 36.42,57.57 35.25,57.57 TP73.1
XDP_PREQ_N: length 10
  IN4 w0.089: v2(40.04,56.03) 39.78,56.29 32.06,56.29 v2(31.35,55.58)
  BOTTOM w0.127: TP78.1 31.1,55.33 v2(31.35,55.58)
XDP_TCK0: length 21.6
  TOP w0.127: v7(40.04,53.98) 39.96,54.06 v4(39.96,54.67) 40.22,54.92 40.22,57.74 40.85,58.37 v4(41.1,58.37)
  IN1 w0.089: v4(41.1,58.37) 41.1,59.28 v5(41.34,59.52) ; v4(41.64,42.59) 41.66,42.59 42.02,42.96 42.02,45.32 41.62,45.72 41.62,46.84 42.43,47.65 42.43,53.55 42.3,53.67 40.35,53.67 39.96,54.06 v4(39.96,54.67)
  IN4 w0.089: v2(41.34,59.07) v5(41.34,59.52)
XDP_TCK1: length 7.4
  TOP w0.127: v6(36.28,46.66) 36.28,46.74 35.94,47.08 35.16,47.08 R112.2
  BOTTOM w0.089: U16.AE62 39.79,47.79 39.51,47.5 39.02,47.5 38.87,47.35
  BOTTOM w0.127: 38.87,47.35 38.16,46.64 36.31,46.64 v6(36.28,46.66) 35.95,46.33 TP109.1
XDP_TDI: length 14.6
  IN1 w0.089: v5(36.79,45.67) 38.59,43.87 v4(38.59,43.39)
  IN4 w0.089: v5(36.79,45.67) 36.28,46.18 35.9,46.18 35.65,46.44 33.77,46.44 v2(33.61,46.28)
  BOTTOM w0.089: U16.AD61 40.27,48.16 39.89,48.16 39.8,48.08 39.04,48.08 38.9,47.93 38.87,47.93
  BOTTOM w0.127: 38.87,47.93 38.77,47.93 37.94,47.11 35.86,47.11 35.62,46.87 34.2,46.87 v2(33.61,46.28)
XDP_TDI_CPU: length 6
  BOTTOM w0.127: U16.F63 39.12,58.28 38.52,58.88 36.11,58.88 35.94,58.72 34.38,58.72 TP71.1
XDP_TDO_CPU: length 10.8
  IN1 w0.089: v4(39.84,58.6) 39.82,58.62 39.41,58.62 39.4,58.62 v5(39.38,58.62)
  IN4 w0.089: v2(39.71,58.65) 39.68,58.62 v5(39.38,58.62)
  BOTTOM w0.127: U16.F62 40.04,58.33 v2(39.71,58.65) 39.7,58.66 39.3,58.66 38.69,59.26 35.95,59.26 35.79,59.1 33.6,59.1 33.44,58.93 31.58,58.93 TP70.1
XDP_TMS: length 9.7
  IN1 w0.089: v5(37.55,46.61) 39.63,44.53 v4(39.63,43.36)
  IN4 w0.089: v5(37.55,46.61) 37.81,46.87 37.81,47.2 37.3,47.71 v2(37.17,47.71)
  BOTTOM w0.089: 38.87,48.25 39.57,48.25 39.86,48.54 U16.AD62
  BOTTOM w0.127: 38.87,48.25 38.66,48.25 38.11,47.71 v2(37.17,47.71) 36.87,47.71 36.79,47.63 TP105.1
XDP_TMS_CPU: length 5.4
  BOTTOM w0.089: 39.13,59.39 40.36,59.39 U16.E61
  BOTTOM w0.127: TP69.1 35.6,59.64 38.87,59.64 39.12,59.39 39.13,59.39
XDP_TRST_CPU: length 23.6
  TOP w0.127: R38.1 40.47,58.76 40.47,58.55 39.84,57.92 39.84,55.48 v7(39.68,55.33) 39.53,55.33 v4(39.2,55)
  IN1 w0.089: v5(35.85,44.96) 35.85,45.45 36.89,46.49 36.89,46.82 37.3,47.22 37.6,47.22 38.62,48.24 38.62,53.42 39.35,54.16 39.35,54.41 39.15,54.61 39.15,54.89 39.2,54.94 v4(39.2,55)
  IN4 w0.089: v2(35.52,45.06) 35.75,45.06 v5(35.85,44.96)
  BOTTOM w0.127: v2(35.52,45.06) 35.62,45.06 39.23,41.46 39.63,41.46 U16.AU62
XDP_TRST_CPU_N: length 3.3
  TOP w0.127: v7(41.79,61.29) 41.88,61.21 R31.1 v4(41.88,60.38) R38.2
  IN1 w0.089: v4(41.88,60.38) 41.88,59.63 v5(41.99,59.52)
  IN4 w0.089: v2(41.99,59.07) v5(41.99,59.52)
XTAL24_DSP_IN: length 5.6
  TOP w0.127: Y1.3 110.27,42.68 110.27,42.29 110.47,42.09 C129.2 110,41.17 110,40.67 R153.1 109.96,40.22 109.96,39.97 109.19,39.2 U10.2
XTAL24_DSP_OUT: length 7.8
  TOP w0.127: Y1.1 109.07,45 109.89,44.18 109.89,42.31 C128.1 109.62,41.68 109.62,40.67 R153.2 109.58,40.31 109.58,40.12 108.69,39.24 U10.3
XTAL24_IN: length 10.5
  BOTTOM w0.127: U16.A25 63.31,61.71 65.05,63.45 66.07,63.45 66.25,63.64 66.25,63.83 65.81,64.28 v7(65.81,64.32) 66.25,64.76 66.25,65.36 66.13,65.49 65.75,65.49 R260.1 65.25,64.98 C242.1 64.05,65.41 63.26,65.41 62.99,65.14 Y2.3
XTAL24_OUT: length 14.4
  BOTTOM w0.127: U16.B25 63.59,61.35 63.59,61.45 65.21,63.07 66.23,63.07 66.63,63.48 66.63,63.83 67.08,64.28 v7(67.08,64.32) 66.63,64.76 66.63,65.52 66.28,65.87 65.88,65.87 R260.2 65.5,66.25 C237.1 64.03,65.79 63.31,65.79 63.1,65.99 60.8,65.99 Y2.1
N91758052: length 3.3
  TOP w0.127: D20.1 223.43,22 223.15,22.28 223.15,22.86 v6(223.05,22.97)
  BOTTOM w0.127: v6(223.05,22.97) 221.55,22.97 Q33.3
N91759939: length 3.3
  TOP w0.127: v6(223.05,19.36) 223.05,18.67 223.32,18.4 D21.1
  BOTTOM w0.127: v6(223.05,19.36) 222.97,19.28 Q34.3
N91761828: length 4.4
  TOP w0.127: D22.1 223.75,14.8 v6(223.15,14.2)
  BOTTOM w0.127: v2(221.96,17.1) 221.96,16.13 v7(223,15.09) 223,14.36 v6(223.15,14.2)
N91763719: length 7.5
  TOP w0.127: v4(223.7,10.54) 223.94,10.78 D23.1 ; v4(222.59,11.05) 222.59,10.44 v7(222.54,10.39)
  TOP w0.254: v7(222.54,10.39) 220.28,12.65 Q20.3
  IN1 w0.089: v4(223.7,10.54) 223.11,10.54 v4(222.59,11.05)
N91886071: length 6.7
  TOP w0.254: v6(223.1,25.99) 223.49,25.6 D19.1
  BOTTOM w0.127: v6(223.1,25.99) 223.1,27.18 222.49,27.79 Q31.3 219.25,27.79 v7(218.97,27.51)
N98656531: length 2.8
  TOP w0.127: D20.2 223.39,21.15 R217.2 v7(222.59,19.97)
N98656602: length 2.8
  TOP w0.127: v7(222.74,16.49) 222.59,16.64 R229.2 223.34,17.6 D21.2
N98656673: length 2.1
  TOP w0.127: R241.2 222.46,14.13 223.19,13.4 D22.2
N98656744: length 4.2
  TOP w0.254: R243.2 v7(222.47,11.84) 223.17,11.14 223.17,10.09 223.46,9.8 D23.2
N100531901: length 2.7
  TOP w0.127: v7(222.59,23.55) R206.2
  TOP w0.254: D19.2 223.43,24.71 R206.2
N122106153: length 9.8
  TOP w0.127: R118.2 80.47,46.01 80.86,45.62 v4(80.86,45.27)
  IN1 w0.089: v5(80.6,44.11) 80.86,44.36 v4(80.86,45.27)
  IN3 w0.089: v2(78.8,44.07) 78.83,44.11 v5(80.6,44.11)
  BOTTOM w0.076: v2(78.8,44.07) 78.26,43.54 75.85,43.54 75.68,43.36 74.9,43.36 74.74,43.52 74.74,43.64 74.28,44.1 U16.AM7
N122106498: length 10.8
  TOP w0.127: v7(83.91,55.78) 83.88,55.81 v4(83.31,55.81) 83.31,54.61 R69.1
  IN1 w0.089: v4(83.31,55.81) 83.17,55.95 v5(83.17,56.18)
  IN3 w0.089: v5(83.17,56.18) 82.8,56.54 79.51,56.54 79.46,56.49 76.39,56.49 v2(75.38,55.48)
  BOTTOM w0.127: U16.L5 v2(75.38,55.48)
N122114083: length 4.2
  BOTTOM w0.089: 79.12,47.97 78.47,47.97 78.4,48.04 77.63,48.04 77.36,47.77 U16.AF2
  BOTTOM w0.127: TP106.1 80.86,47.58 80.27,48.16 79.39,48.16 79.19,47.97 79.12,47.97
N122114085: length 4
  BOTTOM w0.089: U16.AD2 77.36,48.6 77.55,48.78 78.71,48.78
  BOTTOM w0.127: 78.71,48.78 78.8,48.88 81.08,48.88 TP101.1
N122114087: length 2.3
  TOP w0.127: v4(77.58,47.55) 77.81,47.32 TP27.1
  IN1 w0.089: v5(77.12,47.78) 77.35,47.78 v4(77.58,47.55)
  IN4 w0.089: v2(76.06,47.71) 77.05,47.71 v5(77.12,47.78)
N122114089: length 5.3
  TOP w0.127: v7(64.37,61.76) 64.09,61.49 v4(64.09,61.24)
  TOP w0.254: R35.1 v4(64.09,61.24)
  IN1 w0.254: v4(64.09,61.24) 63.92,61.07 v5(63.81,61.07)
  IN4 w0.254: v2(64.42,61.5) 64.25,61.5 v5(63.81,61.07)
  BOTTOM w0.127: U16.C26 62.74,60.29 63.18,60.74 63.48,60.74 v5(63.81,61.07) 64.12,61.07 64.42,61.37 v2(64.42,61.5)
N122114106: length 6.5
  BOTTOM w0.127: U16.B35 57.52,61.42 57.52,62.01 55.99,63.53 55.99,64.27 56.25,64.52 56.25,65.61 55.71,66.15 TP53.1
N122114113: length 4.1
  BOTTOM w0.127: U16.A35 57.16,61.96 55.71,63.4 TP62.1
N122118059:
  vias: v6(134.05,41.56)
N122135977: length 5.9
  TOP w0.127: PR49.1 PR48.2 PR47.2 ; PR49.1 107.16,44.77 v7(107.35,44.96) ; PR49.1 105.67,45.53 105.67,46.28 105.42,46.54 PQ6.5
N122135991: length 12.5
  TOP w0.127: v7(112.33,45.75) 112.19,45.89 PR37.2
  TOP w0.254: PQ6.2 107.6,46.54 107.73,46.66 107.73,47.19 ; 107.73,47.19 PQ6.3 ; 107.73,47.19 107.73,47.5 107.55,47.68 106.87,47.68 106.66,47.88 PQ3.2 108.42,48.42 108.67,48.16 108.67,47.4 109.48,47.4 109.69,47.2 109.69,46.82 110.07,46.44 111.49,46.44 111.72,46.66 PR37.2
N122136003: length 3.9
  TOP w0.127: v6(104.66,51.01) 104.68,50.98 PQ3.3 103.69,48.09 PR36.1
N122136058: length 8.7
  TOP w0.254: PR33.2 PR36.2 PC24.1 101.56,46.32 101.56,45.42 101.84,45.14 101.84,43.72 v7(101.05,42.93) 100.03,41.91 PQ9.4
N122136064: length 10.5
  TOP w0.127: PR33.1 103.39,49.1 103.68,49.39 103.68,50.72 104.43,51.46 106.1,51.46 108.13,49.43 PQ4.3 109.69,50.73 v7(109.66,50.75)
N122136143: length 2.7
  TOP w0.127: v7(103.49,45.04) 103.09,45.44 PR39.2 103.59,45.93 103.63,45.89 PQ6.6
N122146009: length 1.7
  TOP w0.127: PU2.10 100.05,52.29 PC8.1
N122146015: length 1.6
  TOP w0.127: PC7.1 99.53,52.07 99.25,51.8 PU2.12
N122148320: length 18
  BOTTOM w0.089: 39.05,40.09 39.09,40.05 39.9,40.05 39.91,40.07 40.19,40.07 40.71,40.59 U16.AV61
  BOTTOM w0.127: U17.2 28.54,41.36 R346.1 29.67,40.98 30.06,40.59 30.06,38.43 v7(29.93,38.31) 30.97,37.27 35.72,37.27 38.54,40.09 39.05,40.09
N122232203: length 0.3
  BOTTOM w0.254: U16.K16 v2(69.35,56.01) ; U16.K14 v2(70.07,55.91)
  vias: v3(69.17,55.99) v3(69.94,55.66) v4(69.17,55.99) v4(69.94,55.66) v5(69.71,56.01) v7(70.32,55.05)
N122232279: length 3.9
  TOP w0.127: C79.1 73.42,50.04 72.83,50.04 72.53,50.35 v7(72.07,50.35)
  TOP w0.254: C79.1 73.91,50.52 v4(73.91,51.01) 73.91,51.52 R90.1
  IN1 w0.089: v5(73.57,50.91) 73.67,51.01 v4(73.91,51.01)
  IN4 w0.089: v5(73.57,50.91) 73.57,50.76 v2(73.43,50.61)
N122232606: length 6.2
  TOP w0.127: v7(72.07,52.13) 72.09,52.1 v4(74.11,52.1)
  TOP w0.254: v4(74.11,52.1) 74.38,52.1 74.58,51.9 C73.2 R82.2
  IN1 w0.254: v5(73.64,52.07) 74.08,52.07 v4(74.11,52.1)
  IN3 w0.254: v5(73.64,52.07) 73.64,51.78 v2(73.43,51.57)
  BOTTOM w0.254: v2(73.43,51.57) 73.43,51.53 U16.W9
N122232726: length 5.4
  TOP w0.127: v4(65.06,47.25) 64.35,46.54 TP30.1
  IN1 w0.089: v4(65.06,47.25) v5(64.7,47.25)
  IN4 w0.089: v5(64.7,47.25) 64.83,47.25 65.36,47.78 65.75,47.78 v2(65.8,47.83)
  BOTTOM w0.127: U16.AC20 66.16,49.01 65.92,48.77 65.92,47.96 v2(65.8,47.83)
N122232731: length 20.5
  TOP w0.127: v7(71.74,47.96) 71.71,47.93 C106.1
  TOP w0.254: v4(71.69,46.82) 71.71,46.84 C106.1
  IN1 w0.254: v4(71.69,46.82) v5(71.33,46.82) 71.33,45.83 72.12,45.04 72.55,45.04 73.09,45.57 73.62,45.57 73.82,45.37 74.79,45.37 74.84,45.32 75.17,45.32 75.3,45.45 76.59,45.45 76.84,45.7 76.84,46.23 77.1,46.49 77.51,46.49 78.42,45.57 80.22,45.57 80.3,45.65 81.01,45.65 81.26,45.39 81.26,44.73 81.52,44.48 83.14,44.48 84.8,46.13
  IN4 w0.254: v2(71.94,46.77) 71.89,46.82 v5(71.33,46.82)
  BOTTOM w0.254: v2(71.94,46.77) 72.1,46.92 U16.AG10
  vias: v3(84.8,46.21) v3(85.18,46.21) v4(84.8,46.21) v4(85.18,46.21)
N122232733: length 3.5
  IN1 w0.089: v4(76.67,47.32) 76.29,47.71 73.94,47.71 v5(73.87,47.78)
  IN4 w0.254: v2(74.23,47.76) 74.2,47.76 74.18,47.78 v5(73.87,47.78)
  BOTTOM w0.254: U16.AE7 v2(74.23,47.76)
N122232990: length 1.1
  TOP w0.127: R62.1 v7(68.03,55.02)
  BOTTOM w0.254: U16.J15 v2(69.61,56.49)
  vias: v3(67.83,56.24) v3(67.83,55.96) v3(67.83,55.66) v3(68.26,56.24) v3(68.26,55.96) v3(68.26,55.66) v4(67.83,56.24) v4(67.83,55.96) v4(67.83,55.66) v4(68.26,56.24) v4(68.26,55.96) v4(68.26,55.66) v5(68.84,56.72) v5(69.22,57.05) v5(69.25,56.52)
N122415913: length 2.6
  TOP w0.127: PC19.1 190.97,47.17 v7(191.04,47.1) 190.73,46.79 PU5.10
N122415919: length 2.6
  TOP w0.127: PC18.1 189.95,47.27 v7(189.77,47.1) 189.93,46.94 PU5.12
N122415954: length 5
  BOTTOM w0.127: EC54.1 R308.1 180.71,50.51 180.71,50.8 181.21,51.31 182.59,51.31 182.85,51.57 J1.40
N122416000: length 5.1
  BOTTOM w0.127: J1.39 183.35,51.42 182.92,50.99 181.4,50.99 181.14,50.73 181.14,50.48 R309.1 EC55.1
N122416321:
  vias: v7(183.96,55.83)
N122428418: length 4.3
  TOP w0.254: U4.N3 136.01,53.52 135.63,53.14 135.63,52.02 v7(135.75,51.9) 136.87,50.78 136.87,50.37
N122428484: length 5.6
  TOP w0.254: D15.1 138.64,50.65 137.45,51.85 v7(137.17,51.85) 136.66,51.85 136.12,52.38 136.12,52.93 136.51,53.32 U4.N4
N122428488: length 9.3
  TOP w0.127: v7(134.4,52.48) 134.2,52.28 v4(134.2,51.77) 134.2,51.72 133.06,50.58 D14.1
  IN1 w0.089: v4(134.2,51.77) 134.58,52.15 134.58,53.04 134.47,53.15 134.47,53.53 134.76,53.82 134.76,54.32 135.01,54.57 135.79,54.57 135.9,54.69 135.9,54.99 136.72,55.81 136.72,56.26 v4(136.51,56.48)
N122428591: length 5.9
  TOP w0.127: R99.1 134.45,50.96 v6(134.68,51.19) 134.81,51.06 v4(135.47,51.06) ; U4.M3 v4(135.76,54.23)
  IN1 w0.089: v4(135.76,54.23) 135.66,54.23 135.19,53.75 135.19,53.34 135.11,53.27 135.11,51.41 v4(135.47,51.06)
N122428978: length 5.9
  TOP w0.127: v4(140.76,59.21) 140.52,58.98 U4.C12 ; D1.1 143.5,60.95 143.5,60.11 v6(143.22,59.82) 142.92,59.53 v4(142.78,59.53)
  IN1 w0.089: v4(142.78,59.53) 142.54,59.29 140.83,59.29 v4(140.76,59.21)
N122429024: length 4.8
  TOP w0.127: D4.1 144.61,59.82 144.17,59.38 143.28,59.38 v7(142.5,58.6) 141.88,57.98 U4.E13
N122431172: length 6.5
  TOP w0.127: U4.K5 v4(136.88,55.48) ; v4(135.85,51.24) 135.85,50.64 C82.1
  IN1 w0.089: v4(135.85,51.24) 135.42,51.67 135.42,53.7 135.65,53.93 135.85,53.93 136.19,54.27 136.19,55 136.66,55.48 v4(136.88,55.48)
N122431206: length 7.1
  TOP w0.127: C45.2 143.47,57.51 v7(143.44,57.48)
  TOP w0.381: v6(143.23,58.62) 143.37,58.75 L1.1 144.13,58.04 144.48,57.7 C45.2
  IN2 w0.381: 139.64,58.98 142.87,58.98 v6(143.23,58.62)
  vias: v3(139.51,57.98) v4(139.51,57.98) v9(139.51,57.98)
N122434299: length 4.4
  TOP w0.254: PQ1.5 131.4,54.28 131.79,53.89 PR26.2 132.42,53.55 v6(132.75,53.88) 132.47,54.16 132.24,54.16 132.05,54.35 PQ1.6
N122439457: length 2.6
  TOP w0.127: PC105.1 192.54,23.32 v6(192.14,23.73) 191.71,24.16 PU14.12
N122439463: length 2.4
  TOP w0.127: PC107.1 191.04,23.55 v6(190.87,23.73) 190.91,23.77 PU14.10
N122446140: length 29.9
  IN1 w0.089: v4(84.82,48.47) 85.91,48.47 86.09,48.65 86.52,48.65 86.67,48.8 86.67,49.41 86.85,49.59 90.26,49.59 93.41,52.73 101.33,52.73 101.48,52.89 101.48,53.04 100.55,53.97 v5(98,53.97)
  IN4 w0.089: v5(98,53.97) v2(97.67,53.97)
  BOTTOM w0.127: U15.7 99.65,51.13 99.26,50.74 R297.2 98.13,50.74 97.29,51.58 97.29,53.47 v6(97.37,53.55) 97.67,53.85 v2(97.67,53.97)
N122446146: length 38.6
  TOP w0.127: R304.2 83.17,52.03 v4(83.17,51.52)
  IN1 w0.089: v4(83.17,51.52) 83.63,51.06 83.73,51.06 83.78,51.01 85.61,51.01 85.93,51.33 89.46,51.33 91.53,53.4 91.53,54.01 92.64,55.12 101.36,55.12 102.08,54.41 102.73,54.41 102.74,54.4 105.55,54.4 106.19,55.04 108.65,55.04 v5(109.34,54.35)
  IN4 w0.102: v5(109.34,54.35) v2(109.99,54.35)
  BOTTOM w0.127: U15.3 110.57,49.86 R312.2 111.34,50.64 v7(111.34,52.68) 109.99,54.03 v2(109.99,54.35)
N122446326:
  vias: v7(100.54,53.93)
N122446520: length 7.3
  TOP w0.127: RTCR3.2 RTCR4.1 209.5,33.24 208.49,34.24 205.88,34.24 205.67,34.45 Q30.1
N122446579: length 17.3
  TOP w0.127: D18.2 200.67,28.3 v7(202.52,26.45) 203.62,25.35 208.59,25.35 210.28,27.04 RTCR3.1
N122446658: length 2.8
  TOP w0.127: Q30.2 206.97,35.26 RTCR2.1 206.96,36.78 RTCR1.2
N122449531: length 6.2
  TOP w0.127: Q7.2 21.8,39.53 R161.1 R160.2 20.44,37.96 19.85,37.37 v7(19.85,36.63)
N122450119: length 2.4
  TOP w0.127: PC118.1 171.03,17.89 v6(171.18,17.73) 170.94,17.49 PU16.10
N122450141: length 2.4
  TOP w0.127: PC117.1 v6(169.89,17.73) 170.14,17.48 PU16.12
N122455005: length 3.7
  BOTTOM w0.127: R352.1 169.62,39.09 v7(169.63,39.1)
  BOTTOM w0.381: R352.1 169.25,38.18 168.32,37.25 CON1.51
N122455420: length 2.4
  TOP w0.127: PC50.1 165.69,40.19 v6(165.64,40.14) 165.91,39.87 PU9.12
N122455426: length 2.4
  TOP w0.127: PC51.1 166.71,40.34 v6(166.91,40.14) 166.71,39.93 PU9.10
N122455442: length 13.8
  TOP w0.127: v7(170.04,33.84) 170.02,33.85 v4(169.12,33.85) ; D25.3 168.69,43.41 v4(168.89,43.21)
  IN1 w0.089: v4(168.89,43.21) 170.11,41.99 170.11,34.84 v4(169.12,33.85)
N122457781:
  vias: v7(182.74,39.04)
N122457865: length 1.1
  TOP w0.127: R172.2 182.84,32.8 v6(182.32,32.8)
N122457919: length 4.9
  TOP w0.127: C159.1 170.91,31.55 R176.1 170.9,31.36 v7(170.9,30.43) 172.16,30.43 R183.1 172.42,31.54 U12.5
N122457968: length 4.7
  TOP w0.127: TP42.1 181.29,27.49 181.09,27.69 179.51,27.69 179.42,27.79 178.83,27.79 v6(178.8,27.82)
  BOTTOM w0.127: v6(178.8,27.82) 179.13,28.15 CN4.38
N122457970: length 2.2
  TOP w0.127: v6(179.23,27.34) 179.81,27.34 TP44.1
  BOTTOM w0.127: v6(179.23,27.34) 179.54,27.65 CN4.40
N122457972: length 3.9
  TOP w0.127: TP45.1 183.58,27.03 182.99,27.61 182.25,27.61 182.03,27.39 v6(182.03,27.36)
  BOTTOM w0.127: CN4.42 181.82,27.15 v6(182.03,27.36)
N122458088: length 3
  TOP w0.127: v7(176.44,31.04) 176.9,30.59 R185.1
  TOP w0.203: R185.1 176.51,30.01 176.02,29.52 U14.5
N122458587: length 3.9
  TOP w0.127: v6(181.7,26.22) 182.1,26.22 v6(182.38,25.94) 182.7,25.62 R205.1
  BOTTOM w0.127: v6(181.7,26.22) 181.7,25.56 181.29,25.15 CN4.50
N122463370: length 3.5
  TOP w0.127: U10.17 102.79,35.86 101.94,35.01 R169.2 101.69,34.87 100.92,34.1 R464.2
N122463954: length 7
  TOP w0.127: v7(100.75,15.52) 100.75,15.19 101.25,14.69 Q19.2
  TOP w0.203: C196.2 102.35,12.4 102.57,12.62 R245.2 102.57,14.06 Q19.2 101.18,13.92 R246.1
N122464013: length 4.5
  TOP w0.127: R246.2 100.27,12.14 100.24,12.17 Q22.3 98.56,12.17 v7(97.24,13.49)
N122468171: length 1.3
  TOP w0.127: R23.1 131.41,63.27 131.33,63.35 Q37.3
N122495028: length 4
  TOP w0.127: U7.16 199.06,48.24 R104.2 199.48,48.84 199.48,50.17 v7(199.27,50.37)
N122495042: length 6.3
  TOP w0.127: U7.4 197.66,44.34 197.47,44.15 197.47,43.67 197.22,43.41 196.33,43.41 196.12,43.62 196.12,43.96 R125.2 195.53,44.53 195.28,44.28 195.28,43.9 C125.2 193.96,43.51 v7(193.89,43.44)
N122495050: length 5.9
  TOP w0.127: U7.7 200.06,42.62 199.83,42.4 199.83,41.86 199.95,41.75 R147.1 ; R147.1 200.94,42.45 v7(201.76,42.45) ; R147.1 200.24,42.32 200.56,42.64 U7.8
N122607796: length 2.2
  BOTTOM w0.127: C270.2 30.82,25.73 v7(30.79,25.71)
  BOTTOM w0.508: C270.2 30.38,26.74 30.26,26.62 R381.1
N122610085: length 1.2
  BOTTOM w0.508: R382.1 55.28,26.62 55.4,26.74 C271.2
N122649084: length 2.3
  BOTTOM w0.127: C272.2 72.66,26.29 71.74,26.29 v7(71.64,26.19)
  BOTTOM w0.508: R383.1 73.34,26.24 73.22,26.36 C272.2
N122814031: length 4.1
  TOP w0.127: v6(110.7,11.51) 110.7,11.51 PR141.1 109.81,12.49 v7(109.79,12.48)
  BOTTOM w0.127: JBAT1.B5 v6(110.7,11.51)
N122814075: length 3.1
  TOP w0.127: PQ15.1 3.13,8.89 3.48,8.89 PR149.1 3.94,7.54 v7(3.92,7.52)
N122814077: length 12.1
  TOP w0.127: PR137.1 4.54,13.31 6.84,13.31 7.2,12.96 7.2,12.17 7.05,12.02 4.84,12.02 4.33,11.51 PQ15.3 5.04,10.75 5.55,11.26 FL1.2 6,10.62 5.94,10.56 PC130.1 6.82,9.17 v7(6.82,9.15)
N122814081: length 5.1
  TOP w0.127: PQ13.3 1.74,15.4 1.74,13.89 PR136.2 2.32,12.55 2.3,12.53 2.3,11.76
N122814089: length 2.8
  TOP w0.127: PR137.2 4.41,13.97 PR135.1 4.58,14.5 PQ13.2
N122814123: length 5.3
  TOP w0.127: PR131.2 10.82,22.68 v7(11.16,23.02)
  TOP w0.381: PQ12.3 9.99,21.8 10.25,22.05 PR131.2 PR124.2 8.57,22.68 8.45,22.56 PR220.1
N122814144: length 4.2
  TOP w0.127: v6(107.7,11.47) 107.66,11.51 PR140.1 106.78,12.49 v7(106.74,12.45)
  BOTTOM w0.127: JBAT1.B3 v6(107.7,11.47)
N122829049: length 1.9
  TOP w0.203: PR58.1 151.34,41.99 151.37,41.97 PU7.3
N122829093: length 2.2
  TOP w0.203: PR57.1 150.74,41.95 150.97,41.72 PU7.4
N122829099: length 3.8
  TOP w0.203: PQ7.3 151.76,45.59 151.47,45.29 151.47,44.02 152.22,43.27 PR59.2
N122829101: length 2.8
  TOP w0.203: PR57.2 149.86,43.27 149.21,43.92 v6(149.21,44.23) 149.27,44.29 PQ7.6
N122829103: length 2.1
  TOP w0.203: PR59.1 151.77,41.77 PU7.2
N122829153: length 2.6
  TOP w0.127: v7(140.29,35.49) 140.29,35.5 PC66.2
  TOP w0.381: PD3.3 139.86,37.16 140.29,36.74 PC66.2
N122829159: length 1.1
  TOP w0.127: PC45.1 141.43,42.1 v7(141.11,42.42)
N122829163: length 2.6
  TOP w0.127: v7(144.23,36.38) 144.21,36.4 PC67.2
  TOP w0.381: PC67.2 143.22,36.84 143.46,37.08 PD2.3
N122829414: length 2.5
  TOP w0.127: PC93.2 v7(161,27.88)
  TOP w0.508: PC93.2 161,29.78 PR109.1
N122829607:
  vias: v7(157.57,39.6)
N122829826: length 3.1
  TOP w0.127: PR108.1 139.25,30.25 v7(139.23,30.23)
  TOP w0.508: PR108.1 140.65,29.82 141.06,29.42 141.06,28.79 PC92.2
N122829933: length 1.1
  TOP w0.127: PC58.1 146.1,37.67 v7(145.81,37.37)
N122830133: length 5.6
  BOTTOM w0.203: PU20.3 151.06,24.89 151.72,25.55 PR204.2 151.34,26.01 151.19,25.86 150.81,25.86 v6(150.78,25.89) 150.45,25.89 150.31,25.74 PC192.1 PC191.1 PR207.1
N122830151: length 8.6
  TOP w0.203: v6(155.67,25.43) 155.59,25.51 v7(154.77,25.51) 154.04,25.51 153.13,24.6 PR219.2 151.83,25.52 PQ31.2
  BOTTOM w0.203: PU20.4 154.11,24.6 154.5,24.21 155.16,24.21 PR208.2 v6(155.67,25.43)
N122832308: length 124.2
  TOP w0.254: PC39.1 125.57,43.13 v6(126.04,42.66) 125.75,42.37 125.69,42.37 PC41.1 PR71.1
  IN2 w0.254: v5(98.94,14.79) 96.38,14.79 90.06,21.11 81.3,21.11 80.99,21.42 72.5,21.42 71.54,20.45 59.09,20.45 v5(56.17,17.53)
  IN3 w0.254: v5(103.06,31.58) 102.83,31.58 102.19,32.21 99.13,32.21 98.47,32.87 95.54,32.87 95.36,32.69 93.28,32.69 91.98,31.4 91.98,28.1 99.91,20.17 99.91,15.75 v5(98.94,14.79)
  IN4 w0.254: v2(102.96,32.08) 103.06,31.98 v5(103.06,31.58) ; v2(56.55,26.78) 55.79,26.01 55.79,18.62 56.17,18.24 v5(56.17,17.53)
  BOTTOM w0.203: PR227.2 v2(102.96,32.08) 103.57,32.69 v7(103.57,32.75) 104.96,34.14 113.78,34.14 114.89,35.26 114.89,38.39 117.43,40.93 122.44,40.93 124.23,42.71 126.02,42.71 126.04,42.69 v6(126.04,42.66)
  BOTTOM w0.254: v2(56.55,26.78) 56.92,26.78 57.66,27.52 PR229.1
N122832375: length 1.1
  TOP w0.203: PU10.2 122.11,36.56
  vias: v7(124.85,37.22)
N122832563: length 2.5
  TOP w0.127: v7(115.99,26.27) 115.94,26.31 PC101.2
  TOP w0.381: PC101.2 114.02,26.31 PR118.1
N122832615: length 1.2
  TOP w0.127: v7(117.76,30.69) 117.76,31.48 PC81.1
N122833795: length 4.8
  BOTTOM w0.127: PC144.1 110.09,63.68 v7(110.32,63.68)
  BOTTOM w0.203: PR168.2 109.05,61.98 109.08,62.01 PC144.1 108.86,62.89 PU17.18
N122833803: length 1.4
  TOP w0.127: PR8.1 100.75,64.21 v7(100.77,64.19)
N122833805: length 1.7
  TOP w0.127: v6(102.55,64.44) v7(103.29,64.44)
  TOP w0.508: v6(102.55,64.44) 102.19,64.8 PC2.1
N122833835: length 1.5
  BOTTOM w0.127: PR171.1 102.07,59.11 102.63,58.55 v6(102.63,58.22)
N122833837:
  vias: v7(99.45,57.64)
N122833953: length 3.6
  BOTTOM w0.127: v7(109.23,59.19) 109.22,59.2 PC152.1
  BOTTOM w0.203: PC152.1 108.71,60.63 108.62,60.63 108.37,60.89 108.37,61.24 107.92,61.69 PU17.21
N122834630: length 5.1
  BOTTOM w0.127: PR214.1 185.9,13.48 v7(185.84,13.54)
  BOTTOM w0.203: PU21.6 186.96,11.32 PR215.2 PC210.2 PR214.1
N122834634: length 4.8
  BOTTOM w0.127: PL8.2 180.18,11.33 v7(178.14,13.36)
N122834704: length 7.2
  BOTTOM w0.127: PR212.2 180,12.77 v7(179.41,13.36)
  BOTTOM w0.203: PC209.1 PR213.2 PR212.2 181.57,12.32 181.32,12.07 181.32,11.49 181.48,11.32 PU21.5
N122836621: length 8.3
  IN4 w0.203: v2(16.72,51.39) 20.76,51.39 v2(20.84,51.46)
  BOTTOM w0.178: PQ19.1 16.29,51.82 v2(16.72,51.39)
  BOTTOM w0.203: v2(20.84,51.46) v7(21.47,51.46) 21.63,51.31 23.23,51.31 23.45,51.54 PR186.2
N122836643:
  vias: v6(16.75,56.77)
N122836645:
  vias: v6(15.53,56.32)
N122836651:
  vias: v7(21.68,60.02)
N122836744: length 38.5
  TOP w0.127: v4(47.59,66.85) 47.21,66.47 PR226.1 47.21,65.47 47.08,65.33 PD9.2
  IN1 w0.089: v6(24.72,53.79) 25.12,54.18 27.52,54.18 28.28,54.94 28.28,63.33 32.01,67.06 47.38,67.06 v4(47.59,66.85)
  BOTTOM w0.178: PU18.3 24.82,54.22 24.72,54.13 v6(24.72,53.79)
  BOTTOM w0.203: v6(24.72,53.79) 24.72,53.56 PR188.1
N122836818: length 5.5
  TOP w0.127: v7(19.77,61.8) 19.78,61.79 PR15.1
  TOP w0.203: v6(20.99,59.24) 20.46,59.77 PR17.1 PR15.1
  BOTTOM w0.178: PU18.15 21.77,57.98 21.27,58.48 21.27,58.96 v6(20.99,59.24)
N122836933: length 2.4
  BOTTOM w0.178: PR187.1 24.22,53.05 24.22,54.13 24.42,54.33 PU18.4
N122837549: length 1.5
  BOTTOM w0.127: v7(9.66,44.07) 9.77,44.18 PR196.1
N122837792: length 1.8
  BOTTOM w0.127: 11.82,45.67 v7(11.82,43.84)
N122837844: length 11.4
  TOP w0.203: v6(26.76,50.12) 29.18,52.53 PR24.1
  BOTTOM w0.203: PR191.2 PC163.1 PR190.1 28.53,51.87 v7(27.44,50.78) 26.98,50.32 26.96,50.32 v6(26.76,50.12)
N122837908: length 2.1
  BOTTOM w0.127: v7(29.17,64.72) 29.3,64.6 PC143.1 PR155.2
N122837932: length 7.4
  BOTTOM w0.203: PL3.3 15.96,47.45 16.16,47.65 16.16,48.8 18.45,51.08 18.45,51.43 PR192.1
N122837950: length 2.2
  BOTTOM w0.127: v7(21.07,52.68) 20.92,52.54 PR194.2
  BOTTOM w0.203: PR194.2 20.15,53.09 20.03,53.21 PR184.2
N122840555: length 2.4
  TOP w0.191: PU15.10 204.17,19.98
  TOP w0.203: 204.17,19.98 v6(204.38,19.77) 204.58,19.97 PC114.1
N122840561: length 2.4
  TOP w0.191: PU15.12 204.12,20.78
  TOP w0.203: PC112.1 204.48,21.14 v6(204.38,21.04) 204.12,20.78
N122840674: length 2.8
  TOP w0.127: PU3.10 123.52,51.7 PC12.1 123.97,52.15 v7(124.55,52.15)
N122840676: length 3
  TOP w0.127: PU3.12 122.72,51.63 PC11.1 121.68,52.68 v6(121.68,52.73)
N122840820: length 2.2
  BOTTOM w0.127: PC177.1 92.69,35.37 92.95,35.62 PU19.6
N122840834: length 5.6
  BOTTOM w0.127: PC179.1 97.28,33.87 v6(97.6,33.56)
  BOTTOM w0.254: PU19.3 95.54,35.62 95.72,35.44 95.72,35.08 96.76,34.04 PC179.1 PR199.1 PR198.2
N122999755: length 6.1
  BOTTOM w0.127: PR151.1 157.75,65.28 157.75,66.08 v7(158.3,66.63)
  BOTTOM w0.254: PR151.1 PR152.2 PC141.2 159.51,64.67 PQ17.2
N122999770: length 2.8
  BOTTOM w0.127: v7(157.03,66.63) 157.31,66.35 PR151.2
  BOTTOM w0.254: PQ18.3 156.68,65.54 156.76,65.62 PR151.2
N123000271: length 2.4
  TOP w0.127: PR18.2 183.79,58.59 v7(184.62,59.42)
  TOP w0.203: PC5.1 PR18.2
N123081936: length 4.1
  TOP w0.127: v7(193.08,33.28) 193.02,33.33 PR101.2
  TOP w0.203: PR101.2 PR93.1 192.51,34.5 192.55,34.46 PU11.6
N123081950:
  vias: v7(193.53,38.66)
N123206003: length 5.9
  BOTTOM w0.127: R264.2 152.11,64.35 151.98,64.22 150.58,64.22 150.3,64.5 v7(150.3,65.18)
  BOTTOM w0.254: R257.2 R264.2 152.71,64.72 152.87,64.88 PQ18.2
N123302860: length 5.4
  BOTTOM w0.165: U16.AW36 56.78,39.37 56.78,38.3 59.33,35.74 TP136.1
N123302864: length 4.1
  BOTTOM w0.165: TP134.1 58.28,36.34 56.42,38.21 U16.AY36
N123302883: length 2.7
  BOTTOM w0.229: TP127.1 53.98,37.54 U16.AY42
N123302892: length 2.5
  BOTTOM w0.229: TP126.1 52.71,37.88 51.69,38.9 U16.AY43
N123302927: length 7.3
  BOTTOM w0.127: TP129.1 61.15,38.21 61.15,40.21 60.77,40.59 60.77,40.82 60.83,40.88 60.83,41.18 60.27,41.74 60.09,41.74 59.19,42.64 U16.AP32
N123305105: length 1.5
  TOP w0.165: TP28.1 54.58,46.22 v6(54.97,45.84)
  BOTTOM w0.165: v6(54.97,45.84) 55.02,45.84 U16.AK38
N123305107: length 11.1
  BOTTOM w0.102: U16.AL38 55.7,45.11 56.65,45.11 56.86,44.91 56.86,44.86
  BOTTOM w0.165: 56.86,44.86 56.86,41.89 55.96,40.99 55.96,38.06 57.03,36.98 TP133.1
N123305111: length 3.5
  BOTTOM w0.229: TP125.1 50.51,37.32 48.92,38.91 48.92,39.36 U16.AW49
N123305113: length 3.9
  BOTTOM w0.229: U16.AV50 48.13,39.97 48.13,38.9 49.11,37.93 TP124.1
N123305142: length 8.8
  BOTTOM w0.127: U16.AL32 58.85,44.45 58.85,43.34 58.87,43.32 58.87,43.02 58.85,42.99 58.85,41.91 59.58,41.18 59.58,38.5 TP128.1
N123329056:
  vias: v7(159.42,44.12)
N123329129: length 3
  TOP w0.127: 158.07,46.41 158.07,46.77 158.51,47.2 v6(158.86,47.2)
  TOP w0.254: PU4.6 158.85,46.18 158.73,46.3 158.62,46.41 PC25.1
N123329141: length 3.6
  TOP w0.127: v6(163.69,44.58) 163.69,44.62 PR45.1 PR38.2 162.49,46.44 162.24,46.18 PU4.3
N123371162: length 3
  TOP w0.127: v7(203.06,42.73) 203.15,42.82 R129.2 202.45,44.34 U7.9
N123381516: length 2.6
  TOP w0.127: TP37.1 125.87,34.04 127.11,34.04 127.25,33.9 PU12.10
N123410461: length 4.9
  TOP w0.127: Q14.3 160.21,23.02 161.22,22 Q15.2 161.22,19.71 v7(161.2,19.69)
N123410463: length 2.4
  TOP w0.127: R208.1 v7(161.75,25.36)
  TOP w0.254: Q15.3 161.88,23.95 161.75,24.08 R208.1
N123704834: length 1.5
  BOTTOM w0.381: TP144.1 145.2,8.39 JP2.1
N123704844: length 1.6
  BOTTOM w0.127: JP2.3 145.25,9.99 TP143.1
N123705164: length 2.6
  BOTTOM w0.127: TP142.1 145.25,14.18 145.05,13.99 JP2.8
N123835164: length 5.3
  TOP w0.127: PC123.1 132.72,14.18 132.17,14.74 132.17,15.14 v7(131.73,15.57)
  TOP w0.203: PR142.2 132.78,13.69 PC123.1 133.51,13.75 133.84,14.07 PQ14.6
N123835172: length 7.4
  TOP w0.127: v7(132.24,11.76) 132.55,11.76 133.13,11.18 PQ16.3
  TOP w0.203: PQ14.2 134.49,11.68 135.34,10.82 PR147.1 134.48,9.87 134.08,10.22 133.69,10.61 PQ16.3
N123835746: length 5
  TOP w0.127: PR130.1 132.97,17.39 v7(132.95,17.4)
  TOP w0.203: PC123.2 132.72,16.24 PR130.1 133.48,15.98 134.07,15.98 134.49,15.56 PQ14.5
N123837873: length 35.6
  TOP w0.127: v4(133.51,35.13) 133.51,34.95 133.94,34.52 133.94,33.15 v7(136.74,30.36) 137.02,30.08 137.02,26.04 140.14,22.92 140.14,19.94 139.68,19.48 139.68,18.49 137.09,15.9 137.09,14.15 136.53,13.59 135.39,13.59 135.14,13.34 PQ14.3
  IN1 w0.089: v4(133.51,35.13) 133.82,35.44 133.82,37.98 133.2,38.6 v4(133.2,42.41)
N123838543: length 6
  TOP w0.127: v6(127.72,38.21) 128.47,38.95 PR81.1
  IN1 w0.508: v4(127.48,41.1) 127.48,40.06 v4(128.58,38.95) 129.48,38.05 v4(130.47,38.05)
N123838812: length 5.8
  TOP w0.203: PQ8.3 135.44,43.57 v6(134.6,42.73) 133.97,42.73 133.51,43.18 132.12,43.18 131.9,42.97 PD1.6
N123839469: length 4.8
  TOP w0.254: PR52.2 132.29,44.15 PQ8.2 133.3,45.48 132.69,45.48 132.37,45.17 v7(132.04,45.17) PC33.1
N123839474: length 5.6
  TOP w0.127: PR218.2 128.91,45.28 v7(128.1,44.48)
  TOP w0.203: PR218.2 129.89,44.39 PR51.1 PR52.1 131.14,43.79 130.7,43.35 PU6.4
N123840210: length 3.5
  TOP w0.127: v7(128.84,8.79) 129.09,8.54 PD7.2
  TOP w0.203: PQ16.1 131.34,8.61 131.28,8.54 PD7.2
N123840213: length 2.5
  TOP w0.127: PR150.2 v7(135.09,7.14)
  TOP w0.203: PQ16.2 134.08,7.85 134.05,7.83 PR150.2
N123896877: length 6.8
  TOP w0.127: PU13.3 97.95,27.34 v4(98.08,27.21) ; PU13.5 98.76,28.14 PR114.1 99.11,27.79 99.69,27.79 PR115.2 99.76,28.01 99.47,28.3 99.47,29.3 v6(99.04,29.72)
  IN1 w0.089: v4(98.08,27.21) v4(98.89,28.02)
N123899946: length 18.9
  BOTTOM w0.076: v2(76.06,47.04) 76.22,47.04 76.53,46.72 78.68,46.72
  BOTTOM w0.127: R315.1 92.77,48.61 89.06,48.61 88.82,48.37 v7(88.22,48.37) 87.98,48.61 82.7,48.61 81.92,47.84 81.92,47.3 81.37,46.74 78.7,46.74 78.68,46.72
N123901413: length 2.5
  BOTTOM w0.127: R388.2 152.49,20.01 v7(152.77,19.74) 152.77,19.37 152.55,19.16 JP1.5
N123966606: length 3.9
  BOTTOM w0.127: Q32.3 v7(169.76,26.27) 169.76,26.12 168.86,25.22 R386.2 R385.2
N123967231: length 2.5
  TOP w0.203: R181.2 183.32,31.25 v6(183.27,31.2) 183.27,31.07 183.86,30.48 U13.12
N123967511: length 2.4
  TOP w0.203: U11.12 183.35,36.22 183.14,36.43 v6(183.14,36.78) 183.27,36.91 R162.2
N123978329: length 8.1
  BOTTOM w0.127: v7(168.23,19.77) 168.48,20.01 R391.2
  BOTTOM w0.381: J2.3 165.05,18.02 165.69,17.38 167.88,17.38 169.12,18.62 R391.2
N124020474: length 2.4
  BOTTOM w0.127: TP141.1 16.74,31.53 16.74,31.77 16.9,31.93 CN3.13
N124071044: length 7.8
  TOP w0.127: v6(138.87,61.93) 138.92,61.98 v9(138.92,62.44) 138.92,62.74 139.02,62.84 R20.2
  IN2 w0.089: v9(138.92,62.44) 138.77,62.44 138.47,62.13 137.17,62.13 136.97,61.93 136.97,60.69 136.84,60.56 136.84,59.97 137.35,59.47 137.35,58.35 137.51,58.19 v9(137.51,57.98)
N124071159: length 4.6
  TOP w0.127: R77.2 R76.2 195.41,54.19 195.4,54.18 193.51,54.18 v7(193.08,54.61)
N124091307: length 7.7
  TOP w0.127: D13.1 131.28,51.08 131.66,51.46 132.88,51.46 v6(133.11,51.69) 133.56,52.15 v4(133.56,52.28)
  IN1 w0.089: v4(135.51,54.95) 134.84,54.95 133.77,53.87 133.57,53.67 133.57,52.28 v4(133.56,52.28)
