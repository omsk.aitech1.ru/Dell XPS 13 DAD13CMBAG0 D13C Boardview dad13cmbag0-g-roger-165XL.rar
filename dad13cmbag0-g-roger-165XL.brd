# Allegro board dad13cmbag0-g-roger-165XL.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
VCCAPLLOPI_VAL: length 6.1
  TOP w0.254: TP13.1 65.87,54.72 65.87,53.93 v4(66.13,53.67)
  IN1 w0.254: v5(66.63,53.93) 66.38,53.93 v4(66.13,53.67)
  IN4 w0.254: v2(66.83,50.63) 66.83,53.73 v5(66.63,53.93)
VCCSENSE: length 23.1
  TOP w0.254: R32.1 39.14,59.76 v4(39.15,59.77)
  IN1 w0.254: v4(39.15,59.77) 39.3,59.92 39.3,60.24 39.78,60.72 39.78,60.92 v5(39.56,61.14)
  IN3 w0.254: v5(39.56,61.14) 39.79,60.91 39.79,60.23 36.92,57.36 32.06,57.36 28.25,61.17 26.88,61.17 26.63,60.91 26.03,60.91 25.75,61.19 25.75,61.44 v2(26.12,61.81)
  IN4 w0.254: v2(39.39,59.07) 39.58,59.26 39.58,60.08 39.84,60.33 39.84,60.86 v5(39.56,61.14)
VCCST_PWRGD#: length 109.1
  TOP w0.127: v4(110.45,66.12) 108.72,66.12 107.4,67.44 92.8,67.44 91.98,66.63 89.06,66.63 88.05,67.64 75.65,67.64 71.92,63.91 61.99,63.91 v7(61.94,63.96) 61.81,64.09 59.12,64.09 58.63,64.57 58.63,64.83 57.52,65.95 v9(57.52,67.34) ; v4(112.23,65.87) 113.67,64.42 118.63,64.42 119.16,63.89 122.9,63.89 123.66,64.65 124.47,64.65 126.04,66.22 129.6,66.22 130.08,65.74 130.08,65.51 130.21,65.38 131.4,65.38 131.99,65.97 Q37.2 132.24,65.84 132.24,62.21 133.49,60.96 135.93,60.96 136.51,60.38 U4.A4
  IN1 w0.089: v4(110.45,66.12) 111.97,66.12 v4(112.23,65.87)
  IN2 w0.089: v5(57.19,67.34) v9(57.52,67.34)
  IN4 w0.089: v5(57.19,67.34) 56.7,66.86 50.58,66.86 50.1,67.34 43.75,67.34 v2(41.62,65.21)
VCCST_PWRGD_L: length 7.4
  BOTTOM w0.127: U16.B59 42.61,61.56 42.61,62.84 42.4,63.05 42.4,64.06 43.6,65.26 Q23.3 43.8,65.87 44.13,65.54 44.13,65.21 44.24,65.1 R261.2
VSSSENSE: length 24.4
  TOP w0.254: R33.1 39.78,59.76 v4(39.76,59.75)
  IN1 w0.254: v4(39.76,59.75) 39.71,59.8 39.71,60.08 40.19,60.55 40.19,60.92 v5(40.41,61.14)
  IN3 w0.254: v5(40.41,61.14) 40.19,60.93 40.19,60.06 38.22,58.09 37.08,56.95 31.9,56.95 28.09,60.76 27.05,60.76 26.8,60.51 25.86,60.51 25.35,61.02 25.35,61.44 v2(24.98,61.81)
  IN4 w0.254: v5(40.41,61.14) 40.24,60.98 40.24,60.16 39.99,59.91 39.99,59.1 39.98,59.09 v2(40.04,59.03)
1P05V_EN: length 5.2
  BOTTOM w0.127: v7(103.79,56.57) 103.97,56.75 103.97,58.2 104.16,58.38 PR174.2
  BOTTOM w0.203: PU17.28 104.72,59.5 104.48,59.26 PR174.2 PR175.2
1P05V_GSNS: length 22.8
  IN3 w0.089: v6(107.59,60.28) 107.33,60.02 106.51,60.02 105.67,59.19 98.33,59.19 97.83,59.69 94.52,59.69 94.22,60 94.22,60.94 93.59,61.56 88.87,61.56 v2(88.61,61.29)
  BOTTOM w0.127: PU17.23 107.59,60.67 v6(107.59,60.28) ; v2(88.61,61.29) 88.12,61.78 PR157.1
1P05V_VREF: length 4.4
  BOTTOM w0.127: v7(108.44,58.15) 108.34,58.04 107.09,58.04 PC156.1
  BOTTOM w0.203: PU17.26 105.52,59.22 106.24,58.5 PC156.1
1P05V_VSNS: length 25.4
  IN3 w0.089: v6(108.27,60.28) 107.64,59.64 106.51,59.64 105.75,58.88 98.26,58.88 97.88,59.26 94.57,59.26 93.89,59.95 93.89,60.96 93.56,61.29 89.24,61.29 v2(88.61,60.66)
  BOTTOM w0.127: v6(108.27,60.28) 108.06,60.49 108.06,61.09 107.86,61.29 PU17.22 ; v2(88.61,60.66) 88.71,60.66 v6(89.04,60.99) 89.06,61.02 PR158.1
1P35V_BOOT:
  vias: v6(119.57,34.14)
1P35V_CS: length 3.4
  TOP w0.127: PR90.2 116.17,35.12 v7(115.96,34.9)
  TOP w0.203: PU10.13 116.93,36.96 116.8,36.83 116.8,36.44 PR90.2
1P35V_FB: length 7.4
  TOP w0.203: PU10.6 120.24,39.12 121.16,40.03 v7(123.63,40.03) 124.61,40.03 PR77.1 PR71.2 PC41.2
1P35V_LGATE: length 7.8
  TOP w0.635: 116.93,34.98 117.18,34.73 117.18,32.85 116.42,32.08 116.42,30.05 TP40.1 117.27,29.21 v6(118.48,29.21)
1P35V_PHASE: length 9
  TOP w0.381: v6(115.83,28.35) 115.38,28.35 v7(115.15,28.12) 115.07,28.05 PC101.1
  IN3 w0.508: v6(118.3,34.45) 118.3,33.43 115.83,30.96 v6(115.83,28.35)
1P35V_S3: length 11.8
  TOP w0.203: PC48.2 119.84,40.45 PU10.7
  TOP w0.254: v4(122.52,43.51) 122.52,41.28 121.7,40.46 PC48.2 ; v4(121.41,43.51) 121.41,43.51 v7(120.89,44.02) 120.63,44.28 PR50.2 119.47,43.89 119.73,43.63 119.73,43.26 PR55.2
  IN1 w0.254: v4(121.41,43.51) v4(122.52,43.51)
1P35V_S5: length 4.6
  TOP w0.127: PR66.2 117.93,42.52 v7(117.97,42.55)
  TOP w0.203: PU10.8 119.44,39.54 PR75.2
  TOP w0.254: PR66.2 117.93,41.11 118.59,40.46 PR75.2
1P35V_TON: length 4.6
  TOP w0.127: v6(115.86,40.77) 116.12,40.51 PR73.1
  TOP w0.203: PU10.9 119.04,39.42 118.58,39.88 117.54,39.88 116.91,40.51 PR73.1
1P35V_UGATE: length 9.3
  TOP w0.508: TP43.1 v6(117.75,27.51)
  IN3 w0.508: v6(117.75,27.51) 117.33,27.51 116.77,28.07 116.77,30.74 119.01,32.97 v6(119.01,34.45)
1P35V_VDD: length 5.6
  TOP w0.127: v7(114.61,39.76) 114.77,39.6 114.77,38.26 115.06,37.97 PR82.1
  TOP w0.203: PU10.12 116.7,37.36 PC64.1 115.28,37.73 PR82.1
1P35V_VDDQ: length 26.1
  TOP w0.203: PU10.5 121.84,37.76 v6(122.13,38.05)
  BOTTOM w0.203: v6(122.13,38.05) 119.97,40.21 117.46,40.21 115.4,38.16 115.4,34.75 114.16,33.51 105.34,33.51 v7(105.01,33.18) 104.1,32.26 PR228.2
1P35V_VID: length 3.4
  TOP w0.127: PR83.2 116.45,38.13 116.67,38.13 117.1,38.56 v6(117.1,39.25)
  TOP w0.203: PU10.11 116.5,37.76 PR83.2
1P35V_VLDOIN: length 20.1
  TOP w0.203: PU10.19 119.84,34.63 120.71,33.76 PC80.1
  TOP w0.508: v6(121.63,33.74) 121.17,33.28 PC80.1
  BOTTOM w0.762: v6(121.63,33.74) 121.68,33.74 120.63,32.69 106.16,32.69 105.76,32.29
8230_BOOT1:
  vias: v6(154.24,39.68)
8230_BOOT2:
  vias: v7(148.55,39.81)
8230_BYP1: length 27.7
  TOP w0.203: v6(163.81,28.02) 163.88,28.08 164.06,28.08 164.44,27.7 164.44,27.25 SJ4.2 ; PC47.1 154.21,40.95 v6(154.09,40.82) 154.06,40.8 154.06,40.24 153.67,39.84 PU7.20
  IN3 w0.203: v6(154.09,40.82) 155.25,40.82 158.89,37.19 164.45,37.19 165.41,36.22 165.41,31.25 164.73,30.56 164.22,30.56 163.23,29.57 163.23,28.4 163.61,28.02 v6(163.81,28.02)
8230_FB1: length 3.8
  TOP w0.203: PR54.2 PR62.1 153.75,42.11 v6(153.2,41.56) 152.44,41.56 152.17,41.29 PU7.1
8230_FB1_P: length 26.1
  TOP w0.203: SJ3.2 164.8,27.3 164.8,27.88 164.17,28.5 163.94,28.5 v6(163.79,28.66)
  TOP w0.254: PR54.1 155.18,43.39 v6(155.84,42.73)
  IN3 w0.203: v6(155.84,42.73) 155.86,42.73 155.89,42.7 155.89,40.87 159.27,37.49 164.58,37.49 165.72,36.35 165.72,31.09 165.01,30.38 165.01,29.87 v6(163.79,28.66)
8230_FB2: length 4
  TOP w0.203: PU7.5 150.57,41.19 150.2,41.56 v6(149.16,41.56) 148.94,41.78 PR61.1 PR53.2
8230_FB2_P: length 26
  TOP w0.203: v6(146.16,40.77) v7(146.87,41.48) 147.47,42.08 147.47,42.69 PR53.1 ; v6(134.43,33.35) 135.57,32.21 136.36,32.21 138.01,30.56 SJ2.2
  BOTTOM w0.203: v6(146.16,40.77) 140.45,40.77 136.43,36.76 136.43,35.36 v6(134.43,33.35)
8230_LGAT2: length 12.1
  TOP w0.381: PC66.1 PC67.1 142.44,35.78 142.71,35.51 TP38.1 142.45,33.74 v6(141.82,33.74)
  TOP w0.635: 148.57,37.16 146.77,37.16 143.6,33.99 TP38.1
8230_LGATE1: length 10.4
  BOTTOM w0.635: 162.77,33.18 162.77,34.33 161.6,35.49 156.45,35.49 154.7,37.24 154.67,37.24
  vias: v6(154.16,37.75)
8230_PHASE1: length 15.6
  TOP w0.508: PC93.1 v7(158.68,28.78) 158.15,28.78 v6(157.64,28.27)
  IN3 w0.508: v6(157.64,28.27) 157.31,28.6 155.75,28.6 154.57,29.79 154.57,33.02 155.74,34.19 155.74,37.09 154.79,38.03
  vias: v6(154.16,38.41)
8230_PHASE2: length 13.2
  TOP w0.127: v6(140.29,28.15) 140.29,27.42 v7(140.29,27.41)
  TOP w0.381: PC92.1 v6(140.29,28.15)
  IN3 w0.508: v6(145.96,28.25) 145.15,29.06 145.15,33.48 147.13,35.46 147.13,37.01 v6(148.5,38.38)
8230_UGATE1: length 12.5
  TOP w0.127: v6(156.37,29.23) 155.66,29.23 TP39.1
  IN3 w0.508: v6(154.16,39.04) 154.87,39.04 156.4,37.52 156.4,33.81 155.69,33.1 155.69,30.31 156.37,29.62 v6(156.37,29.23)
8230_UGATE2: length 13
  TOP w0.508: TP41.1 144.03,29.24 v6(144.08,29.19)
  IN3 w0.508: v6(148.55,39.04) 148.02,39.04 146.21,37.24 146.21,35.82 144.38,33.99 144.38,29.49 v6(144.08,29.19)
8230_VIN: length 6.7
  TOP w0.127: PR92.2 v7(148.19,35.49)
  TOP w0.203: PC73.2 150.41,35.4 150.97,35.95 PU7.12 ; PC73.2 150.4,36.28 150.57,36.44 PU7.11 ; PC73.2 149.92,35.4 149.83,35.49 PR92.2
51622_ALERT#: length 2.9
  BOTTOM w0.178: PU18.32 26.71,55.58 v6(27.59,54.69) 27.98,54.31 PR183.1
51622_B-RAMP: length 4.4
  TOP w0.203: PR22.1 20.79,56.34 v6(20.89,56.24)
  BOTTOM w0.178: v6(20.89,56.24) 20.9,56.23 21.03,56.23 21.18,56.38 PU18.11
  BOTTOM w0.203: PR177.2 20.03,57.6 20.55,57.09 20.55,56.86 20.89,56.52 v6(20.89,56.24)
51622_COMP: length 9
  BOTTOM w0.127: PR155.1 27.6,62.94 v7(27.39,63.15)
  BOTTOM w0.178: PC151.1 27.54,60.79 27.26,60.51 27.26,58.5 26.74,57.98 PU18.26
  BOTTOM w0.203: PR170.2 29.18,60.01 PC151.1 PR160.1 28.4,62.34 28.28,62.45 PR155.1
51622_CSN1: length 25.1
  IN3 w0.203: v2(20.15,51.76) 20.03,51.89 20.03,59.64 21.3,60.91 23.07,60.91 23.48,61.32 23.48,61.82 v2(23.71,62.05)
  BOTTOM w0.178: PU18.18 23.22,59.55 23,59.77 23,60.19 PC150.2
  BOTTOM w0.203: PL3.4 16.72,47.45 16.49,47.68 16.49,48.62 18.83,50.96 18.83,51.46 PR193.2 v2(20.15,51.76) ; PC150.2 PC145.2
51622_CSP1: length 17.7
  IN3 w0.203: v2(22.95,62.05) 23.16,61.83 23.16,61.51 22.95,61.29 21.17,61.29 19.63,59.76 19.63,54.03 v2(19.26,53.67)
  BOTTOM w0.127: v7(18.25,53.55) 18.37,53.67 PR184.1 v2(19.26,53.67)
  BOTTOM w0.178: PU18.17 22.82,59.44 22.67,59.59 22.67,60.35 22.94,60.63 PC150.1
  BOTTOM w0.203: PR192.2 PR193.1 19.14,53.07 19.25,53.18 PR184.1 ; PC150.1 PC145.1
51622_DROOP: length 14.2
  BOTTOM w0.178: PC143.2 29.78,63.42 29.78,64.92 29.42,65.28 28.74,65.28 28.46,65 28.46,64.67 28.08,64.29 27.75,64.29 26.81,63.35 26.81,62.08 v7(27.06,61.83) 26.86,61.62 26.86,58.58 26.66,58.38 PU18.25
  BOTTOM w0.203: PC143.2 29.18,62.82 PR160.2 PC151.2
51622_F-IMAX: length 5.6
  TOP w0.127: v7(22.01,55.3) 21.02,55.3 v6(20.86,55.45)
  TOP w0.203: v6(20.86,55.45) 20.61,55.2 PR25.1
  BOTTOM w0.178: PU18.10 21.39,55.98 v6(20.86,55.45)
  BOTTOM w0.203: v6(20.86,55.45) 20.86,55.58 20.38,56.06 20.38,56.38 PR178.2
51622_GFB: length 2.4
  BOTTOM w0.178: PR166.2 25.54,60.47 25.54,59.85 25.22,59.53 PU18.23
51622_IMON: length 4.8
  TOP w0.203: PR21.1 20.83,58.51 v7(20.91,58.42) 20.91,57.84 v6(20.74,57.66)
  BOTTOM w0.178: v6(20.74,57.66) 20.83,57.57 21.21,57.57 21.6,57.18 PU18.13
  BOTTOM w0.203: PC154.1 20.03,58.62 20.74,57.92 v6(20.74,57.66)
51622_O-USR: length 3.9
  BOTTOM w0.178: PU18.9 21.7,55.58 21.51,55.39 21.51,55.06 v6(20.99,54.54) 20.19,54.54 PR182.1
  BOTTOM w0.203: PR180.2 19.96,55.25 20.03,55.17 PR182.1
51622_OCP-I: length 4.8
  TOP w0.127: PR20.1 18.08,57.73 v7(17.97,57.84)
  TOP w0.203: v6(21.07,57.03) 20.48,57.03 20.03,57.48 PR21.2 PR20.1
  BOTTOM w0.178: v6(21.07,57.03) 21.32,56.78 PU18.12
51622_PWM1: length 9.3
  TOP w0.254: v6(16.77,55.96) 18.58,54.16 v7(21.24,54.16) v6(23.62,54.16)
  BOTTOM w0.178: v6(16.77,55.96) 16.6,55.96 16.29,55.66 PQ19.8 ; v6(23.62,54.16) PU18.6
51622_SKIP#: length 2.5
  BOTTOM w0.178: PR186.1 23.45,53.45 v6(23.3,53.6) 23.12,53.78 23.12,54.34 23.22,54.43 PU18.7
51622_THERM: length 10.4
  BOTTOM w0.178: PU18.14 21.71,57.58 20.51,58.78 20.51,59.3 PC153.1
  BOTTOM w0.203: PR172.2 17.69,58.81 17.69,61.02 18.37,61.7 v7(19.75,61.7) 20.03,61.41 PR169.1 PC153.1
51622_V5A: length 1.8
  TOP w0.127: v6(27.67,57.18) 28.08,56.77 v7(28.28,56.77)
  TOP w0.508: PR19.1 28.25,57.76 v6(27.67,57.18)
51622_VCLK: length 4.4
  TOP w0.127: v7(28.46,54.51) 28.4,54.57 PR24.2 28.08,55.45 v6(27.67,55.86)
  BOTTOM w0.178: PU18.31 27.55,55.98 v6(27.67,55.86)
  BOTTOM w0.203: v6(27.67,55.86) 28.08,55.45 PR181.1
51622_VDIO: length 4.3
  BOTTOM w0.178: PU18.1 25.62,54.33 25.8,54.14 26.26,54.14 v6(26.65,53.75) 27.52,52.89 PR189.1 PR190.2
51622_VDO: length 4.8
  TOP w0.381: v6(25.46,53.6) 25.64,53.78 v7(26.17,53.78) 26.17,52.81 PR27.1
  BOTTOM w0.178: PU18.2 25.22,54.06 25.46,53.81 v6(25.46,53.6)
  BOTTOM w0.381: PC162.1 25.88,53.42 25.64,53.42 v6(25.46,53.6)
51622_VFB: length 2.3
  BOTTOM w0.178: PR167.2 26.12,59.92 25.62,59.42 PU18.24
51622_VR_HOT: length 2.4
  BOTTOM w0.178: PR179.1 27.7,56.6 v6(27.59,56.49) 27.48,56.38 PU18.30
51622_VR_ON: length 2.8
  BOTTOM w0.178: PR185.1 22.44,53.19 v6(22.03,53.6) 22.82,54.38 PU18.8
51622_VREF: length 22
  TOP w0.381: PR17.2 v6(18.3,59.77)
  IN4 w0.381: v6(18.3,57.13) 17.59,57.84 17.59,59.34 18.02,59.77 v6(18.3,59.77) 18.63,59.77 21.32,62.47 27.11,62.47 27.77,61.8 v6(27.77,60.28)
  BOTTOM w0.127: v6(17.76,55.97) 18.03,55.71 PR180.1
  BOTTOM w0.381: PR172.1 17.99,57.43 v6(18.3,57.13) 18.91,57.74 PR177.1 PR178.1 19.25,56.23 19.18,56.16 PR180.1
+5P0V_PROCHOT: length 50.4
  TOP w0.127: PQ31.3 153.15,28.12 153.58,27.69 155.08,27.69 v6(156.3,26.47) ; v4(132.55,41.69) PD1.5
  IN1 w0.089: v4(132.55,41.69) 132.55,37.32 131.99,36.76 131.99,34.32 131.53,33.86 v9(130.52,33.86)
  IN2 w0.089: v6(156.3,26.47) 155,27.77 155,28.81 154.16,29.65 154.16,32.08 152.71,33.53 145.86,33.53 142.27,29.95 133.21,29.95 130.52,32.64 v9(130.52,33.86)
  BOTTOM w0.127: v7(155.03,26.22) 155.28,26.47 v6(156.3,26.47)
+DC_IN:
  vias: v7(9.64,26.8) v7(9.74,25.35) v7(34.33,32.87) v10(7.43,24.59) v10(8.24,24.62) v10(9.05,24.59)
+DC_IN_S: length 33.5
  TOP w0.305: PR89.1 131.42,36.68 132.95,36.68 133.18,36.45 133.18,35.49 133.08,35.39 133.08,34.88 133.59,34.37 133.59,32.87 135.34,31.12 135.34,29.42 PD4.2 133.28,27.67 132.7,28.25 132.7,28.26 132.05,28.91 v4(131.91,28.91)
  IN1 w0.305: v4(131.91,28.91) 131.48,28.48 130.18,28.48 129.5,29.16 126.12,29.16 121.37,24.41 116.6,24.41 v5(116.16,24.85)
  vias: v1(94.37,30.41) v1(94.37,30.15) v1(94.37,29.9) v1(94.37,29.65) v1(94.37,29.34) v1(94.73,30.41) v1(94.73,30.15) v1(94.73,29.9) v1(94.73,29.65) v1(94.73,29.34) v1(95.11,30.41) v1(95.11,30.15) v1(95.11,29.9) v1(95.11,29.62) v1(95.11,29.37) v1(95.49,30.41) v1(95.49,30.15) v1(95.49,29.9) v1(95.49,29.62) v1(95.49,29.37) v1(95.87,30.41) v1(95.87,30.15) v1(95.87,29.9) v1(95.87,29.62) v1(95.87,29.37) v1(114.39,23.45) v1(114.39,23.07) v1(114.39,22.69) v1(114.39,22.31) v1(114.39,21.92) v1(114.39,21.54) v1(114.77,23.45) v1(114.77,23.07) v1(114.77,22.69) v1(114.77,22.31) v1(114.77,21.92) v1(114.77,21.54) v1(115.15,23.45) v1(115.15,23.07) v1(115.15,22.69) v1(115.15,22.31) v1(115.15,21.92) v1(115.15,21.54) v1(115.53,23.45) v1(115.53,23.07) v1(115.53,22.69) v1(115.53,22.31) v1(115.53,21.92) v1(115.53,21.54) v1(115.91,23.45) v1(115.91,23.07) v1(115.91,22.69) v1(115.91,22.31) v1(115.91,21.92) v1(115.91,21.54) v1(116.29,23.45) v1(116.29,23.07) v1(116.29,22.69) v1(116.29,22.31) v1(116.29,21.92) v1(116.29,21.54) v1(116.67,23.45) v1(116.67,23.07) v1(116.67,22.69) v1(116.67,22.31) v1(116.67,21.92) v1(116.67,21.54) v1(117.05,23.45) v1(117.05,23.07) v1(117.05,22.69) v1(117.05,22.31) v1(117.05,21.92) v1(117.05,21.54) v1(117.43,23.45) v1(117.43,23.07) v1(117.43,22.69) v1(117.43,22.31) v1(117.43,21.92) v1(117.43,21.54) v2(94.37,30.41) v2(94.37,30.15) v2(94.37,29.9) v2(94.37,29.65) v2(94.37,29.34) v2(94.73,30.41) v2(94.73,30.15) v2(94.73,29.9) v2(94.73,29.65) v2(94.73,29.34) v2(95.11,30.41) v2(95.11,30.15) v2(95.11,29.9) v2(95.11,29.62) v2(95.11,29.37) v2(95.49,30.41) v2(95.49,30.15) v2(95.49,29.9) v2(95.49,29.62) v2(95.49,29.37) v2(95.87,30.41) v2(95.87,30.15) v2(95.87,29.9) v2(95.87,29.62) v2(95.87,29.37) v2(114.39,23.45) v2(114.39,23.07) v2(114.39,22.69) v2(114.39,22.31) v2(114.39,21.92) v2(114.39,21.54) v2(114.77,23.45) v2(114.77,23.07) v2(114.77,22.69) v2(114.77,22.31) v2(114.77,21.92) v2(114.77,21.54) v2(115.15,23.45) v2(115.15,23.07) v2(115.15,22.69) v2(115.15,22.31) v2(115.15,21.92) v2(115.15,21.54) v2(115.53,23.45) v2(115.53,23.07) v2(115.53,22.69) v2(115.53,22.31) v2(115.53,21.92) v2(115.53,21.54) v2(115.91,23.45) v2(115.91,23.07) v2(115.91,22.69) v2(115.91,22.31) v2(115.91,21.92) v2(115.91,21.54) v2(116.29,23.45) v2(116.29,23.07) v2(116.29,22.69) v2(116.29,22.31) v2(116.29,21.92) v2(116.29,21.54) v2(116.67,23.45) v2(116.67,23.07) v2(116.67,22.69) v2(116.67,22.31) v2(116.67,21.92) v2(116.67,21.54) v2(117.05,23.45) v2(117.05,23.07) v2(117.05,22.69) v2(117.05,22.31) v2(117.05,21.92) v2(117.05,21.54) v2(117.43,23.45) v2(117.43,23.07) v2(117.43,22.69) v2(117.43,22.31) v2(117.43,21.92) v2(117.43,21.54) v7(75.14,30.18) v7(91.15,30.05) v7(116.27,20.35) v8(94.37,30.41) v8(94.37,30.15) v8(94.37,29.9) v8(94.37,29.65) v8(94.37,29.34) v8(94.73,30.41) v8(94.73,30.15) v8(94.73,29.9) v8(94.73,29.65) v8(94.73,29.34) v8(95.11,30.41) v8(95.11,30.15) v8(95.11,29.9) v8(95.11,29.62) v8(95.11,29.37) v8(95.49,30.41) v8(95.49,30.15) v8(95.49,29.9) v8(95.49,29.62) v8(95.49,29.37) v8(95.87,30.41) v8(95.87,30.15) v8(95.87,29.9) v8(95.87,29.62) v8(95.87,29.37) v8(114.39,23.45) v8(114.39,23.07) v8(114.39,22.69) v8(114.39,22.31) v8(114.39,21.92) v8(114.39,21.54) v8(114.77,23.45) v8(114.77,23.07) v8(114.77,22.69) v8(114.77,22.31) v8(114.77,21.92) v8(114.77,21.54) v8(115.15,23.45) v8(115.15,23.07) v8(115.15,22.69) v8(115.15,22.31) v8(115.15,21.92) v8(115.15,21.54) v8(115.53,23.45) v8(115.53,23.07) v8(115.53,22.69) v8(115.53,22.31) v8(115.53,21.92) v8(115.53,21.54) v8(115.91,23.45) v8(115.91,23.07) v8(115.91,22.69) v8(115.91,22.31) v8(115.91,21.92) v8(115.91,21.54) v8(116.29,23.45) v8(116.29,23.07) v8(116.29,22.69) v8(116.29,22.31) v8(116.29,21.92) v8(116.29,21.54) v8(116.67,23.45) v8(116.67,23.07) v8(116.67,22.69) v8(116.67,22.31) v8(116.67,21.92) v8(116.67,21.54) v8(117.05,23.45) v8(117.05,23.07) v8(117.05,22.69) v8(117.05,22.31) v8(117.05,21.92) v8(117.05,21.54) v8(117.43,23.45) v8(117.43,23.07) v8(117.43,22.69) v8(117.43,22.31) v8(117.43,21.92) v8(117.43,21.54)
+DC_IN_SS: length 49.8
  TOP w0.254: v4(133.82,31.83) PR105.1 ; v4(121.75,19.38) 121.75,17.76 120.05,16.06 120.05,11.16 121.19,10.01 126.76,10.01 129.63,7.14 PR150.1
  TOP w0.508: v4(121.75,19.38) 122.2,19.38 123.05,20.22 v6(123.05,20.53) 123.05,21.38 PR231.1 122.84,21.48 EC13.1 120.63,21.48 EC14.1
  IN1 w0.254: v4(121.75,19.38) 121.52,19.6 121.52,20.32 123,21.8 123.91,21.8 129.65,27.54 132.1,27.54 133.82,29.26 v4(133.82,31.83)
+DCIN_JACK:
  vias: v6(8.34,20.91) v6(8.34,20.27) v6(8.34,19.64) v6(8.34,19) v7(9.1,19.11)
+DCPSUSBYP: length 1
  TOP w0.508: C525.2 v4(67.37,45.81)
  vias: v1(67.49,46.92) v2(67.49,46.92) v5(67.49,46.37)
+DDR_VTTREF: length 2.9
  TOP w0.127: PC63.1 123.01,38.35 v7(123.02,38.36)
  TOP w0.203: PU10.4 122.15,37.36 122.26,37.47 PC63.1
+DSP_VREF_IN: length 6.5
  TOP w0.254: v7(115.22,31.83) 115.22,31.84 PR106.1 113.41,32.74 PR103.2 C157.2 112.85,34.09 112.74,33.97 C158.1 111.59,33.97 111.48,33.86 U10.40
+DVDIO:
  vias: v1(105.78,39.17) v1(105.78,38.84) v2(105.78,39.17) v2(105.78,38.84) v3(104.43,40.85) v3(104.43,40.54) v4(104.43,40.85) v4(104.43,40.54) v5(104.1,41) v8(105.78,39.17) v8(105.78,38.84)
+KB_LED_PWR: length 3.3
  BOTTOM w0.508: FS1.2 164.25,21.14 164.86,20.53 v6(164.86,19.94) 164.55,19.94 164.25,19.64 J2.4
+LCDVCC: length 14.5
  IN3 w1.524: 184.31,53.8 184.31,51.24 185.46,50.09 195.79,50.09
  vias: v6(183.22,54.59) v6(183.22,53.95) v6(183.83,54.21) v6(200.59,51.26) v6(200.92,50.7) v6(201.23,51.26) v7(183.09,52.56)
+LED_BL: length 12
  TOP w0.203: v10(169.17,53.24) 169.26,53.33 169.26,55.14 PR13.1
  vias: v6(201.99,51.26) v6(201.99,50.63) v6(202.63,51.26) v6(202.63,50.63) v7(169.12,51.26) v7(202.24,52.05) v10(169.17,52.51)
+LED_PWRSRC: length 18
  TOP w0.305: PU1.23 182.12,59.38 v6(182.19,59.31)
  IN3 w0.254: v6(182.19,59.31) 180.29,57.41 172.09,57.41 170.12,59.38 v6(170.12,62.66)
  vias: v7(167.6,66.5)
+PWR_SRC: length 30.4
  TOP w0.508: v10(13.47,58.68) 13.47,59.08 13.17,59.39 EC77.1 ; v10(12.71,58.68) 12.15,59.24 EC78.1
  IN1 w0.203: v5(114.87,32.95) 114.87,38.56 115.78,39.48 115.78,40.4 v4(116.67,41.29)
  IN4 w0.203: v5(114.87,32.95) 114.54,32.62 v2(114.54,24.36)
  BOTTOM w0.203: PR204.1 152.49,26.26 151.85,26.9 151.85,30 152.23,30.38 ; v2(114.54,24.36) PQ25.8
  BOTTOM w0.381: 22.44,64.62 21.68,63.86 PR165.1
  BOTTOM w0.508: EC69.1 v6(13.68,63.45) ; EC79.1 v6(13.68,64.47)
  vias: v6(147.3,32.98) v6(147.29,32.34) v6(156.33,32.62) v6(156.33,31.96) v7(12.74,56.32) v7(108.14,65.97) v7(118.55,26.4) v7(145.49,32.33) v7(156.98,33.01) v7(159.47,67.14) v10(12.74,57.89) v10(12.74,57.13) v10(13.5,57.89) v10(13.5,57.13) v10(14.23,58.68) v10(14.26,57.89) v10(14.26,57.13) v10(22.31,66.76) v10(22.31,65.87) v10(22.31,64.98) v10(115.66,67.29) v10(116.42,67.29) v10(117.18,67.29) v10(117.94,67.29) v10(121.42,12.35) v10(122.17,12.35) v10(122.92,12.35) v10(123.71,25.13) v10(123.67,12.35) v10(124.42,12.35) v10(124.47,25.89) v10(124.47,25.15) v10(124.72,13.13) v10(125.21,25.86) v10(125.21,12.37) v10(125.46,13.11) v10(125.97,26.62) v10(125.96,12.37) v10(126.2,13.09) v10(151.78,32.59) v10(151.85,31.83) v10(151.85,31.07) v10(152.54,32.57) v10(152.59,31.83) v10(152.59,31.07) v10(159.09,66.48) v10(160.03,66.48) v10(160.79,65.66) v10(161.53,65.66) v10(162.27,66.68) v10(163.08,66.65)
+RTC_1: length 5.2
  TOP w0.508: RTCBT1.2 214.42,32.08 RTCR4.2
+RTC_CELL: length 190.1
  TOP w0.508: D18.3 199.14,32.06 C163.1 197.55,31.71 v6(197.55,31.7) ; v6(87.26,39.24) 87.59,39.56 87.59,42.32 87.08,42.83 R122.2 ; v6(72.86,33.15) 72.86,32.97 73.62,32.21 73.62,30.96 ; v6(132.22,52.58) 132.22,52.48 132.17,52.53 C69.1 ; 73.62,30.96 R180.2 ; 73.62,30.96 R179.2
  IN3 w0.508: 117.23,49.89 117.97,49.89 119.81,51.73 131.37,51.73 v6(132.22,52.58) 135.85,56.21 v5(135.98,56.21) 136.48,56.21 137.98,54.72 144.66,54.72 147.71,51.67 148.78,51.67 149.46,52.35 163.13,52.35 166.48,49 166.48,46.33 167.68,45.13 173.6,45.13 174.46,44.28 180.71,44.28 181.19,43.79 184.55,43.79 189.06,39.28 189.06,33.38 192.31,30.13 196.66,30.13 197.01,30.48 197.01,31.17 v6(197.55,31.7) ; v6(87.26,39.24) 88.16,40.14 92.57,40.14 94.7,38 94.7,37.27 96.71,35.26 98.49,35.26 99.65,34.09 100.92,34.09 101.2,34.37
  BOTTOM w0.508: v6(72.86,33.15) 73.01,33 75.05,33 R361.1 R362.1 76.89,32.87 78.95,32.87 79.46,33.38 ; 116.55,49.38 116.55,43.49 108.29,35.23 104.07,35.23 v7(104.05,35.26) 103.34,34.55 102.47,34.55 102.42,34.5 102.42,33.89 99.34,30.8 96.7,30.8 95.74,31.76 83.39,31.76 82.15,33 79.84,33 79.46,33.38 ; 79.46,33.38 R365.1
  vias: v1(101.69,34.68) v1(101.69,34.32) v1(116.44,49.84) v1(116.69,49.84) v2(101.69,34.68) v2(101.69,34.32) v2(116.44,49.84) v2(116.69,49.84) v3(136.42,56.03) v4(136.42,56.03) v8(101.69,34.68) v8(101.69,34.32) v8(116.44,49.84) v8(116.69,49.84)
+SMDDR_VREF_CA: length 38.6
  TOP w0.508: v6(94.35,14.28) 94.99,14.28 C190.1 ; v6(50.38,14.3) 51.13,14.3 C186.1 ; v6(60.92,15.35) 61.44,15.86 C179.1 ; C191.1 15.65,13.37 v7(15.45,13.57) 15.45,14.41 v6(15.61,14.57) ; v6(28.02,14.3) 27.4,14.3 C184.1 ; v6(80.98,14.57) 81.2,14.57 82.23,13.54 C181.1 ; v6(37.16,14.57) 37.19,14.59 38.15,14.59 38.43,14.31 C185.1
  IN1 w0.508: v6(50.77,25.61) 51.83,24.55 v6(51.83,17.1) ; v5(72.12,14.36) 71.24,13.48 v4(71.24,12.65)
  IN4 w0.305: v2(71.59,14.41) 71.64,14.36 v5(72.12,14.36)
  BOTTOM w0.203: U25.M8 92.94,14.56 94.07,14.56 v6(94.35,14.28) ; v6(28.02,14.3) 27.71,14.3 27.45,14.57 26.79,14.57 U19.M8 ; U23.M8 70.2,14.24 70.53,14.57 71.43,14.57 v2(71.59,14.41) ; v6(60.92,15.35) 60.14,14.57 59.53,14.57 59.14,14.17 v2(59.03,14.17) ; U21.M8 49.13,14.56 50.12,14.56 v6(50.38,14.3)
  BOTTOM w0.216: U18.M8 v6(15.61,14.57)
  BOTTOM w0.381: v6(80.98,14.57) U24.M8
  BOTTOM w0.508: v6(50.77,25.61) 50.77,26.81 51.48,27.52 R377.1 R378.2 52.91,27.64 R373.2 ; v6(37.16,14.57) 37.16,14.57 37.56,14.17 U20.M8
+SMDDR_VREF_DQA: length 63.9
  TOP w0.508: C175.1 54.65,17.86 v6(54.74,17.77) ; v6(43.67,16.95) 43.99,16.95 C172.1 ; v6(32.48,17.65) 32.7,17.65 32.99,17.94 C170.1 ; v6(21.32,16.95) 21.32,16.97 20.81,17.48 C174.1
  IN2 w0.508: v6(24.06,19.64) 23.65,20.05 21.48,20.05 20.69,19.26 20.69,17.58 v6(21.32,16.95)
  IN3 w0.508: v6(43.67,16.95) 44.69,16.95 45.48,17.73 v6(45.48,19.38)
  IN4 w0.508: v6(54.74,17.77) 54.09,18.43 54.09,19.11 52.92,20.27 52.54,20.27 51.72,19.46 45.53,19.46 45.48,19.41 ; 45.48,19.41 v6(45.48,19.38) ; 45.48,19.41 45.12,19.77 42.61,19.77 42.1,20.27 39.91,20.27 39.1,19.46 36.69,19.46 34.43,17.2 32.93,17.2 32.48,17.65 ; 32.48,17.65 v6(32.48,17.65) ; 32.48,17.65 31.68,18.45 31.68,19.51 30.87,20.32 28.71,20.32 28.03,19.64 v6(24.06,19.64) 24.06,24.63 v6(25.93,26.5)
  BOTTOM w0.381: U19.H1 32.27,17.65 v6(32.48,17.65) ; U21.H1 v6(54.74,17.77) ; U20.H1 43.25,17.37 v6(43.67,16.95) ; U18.H1 20.9,17.37 v6(21.32,16.95)
  BOTTOM w0.508: R372.2 27.89,27.64 R376.2 R375.1 26.56,27.52 25.93,26.89 v6(25.93,26.5)
+SMDDR_VREF_DQB: length 77.1
  TOP w0.508: v6(87.54,16.95) 87.7,17.11 C177.1 ; 75.52,20.91 84.87,20.91 86.75,19.03 87.62,19.03 88.48,18.18 C177.1 ; 75.52,20.91 75.5,20.88 75.5,18.5 76.01,17.99 C171.1 76.15,17.44 v6(76.36,17.23) ; 75.52,20.91 65.11,20.91 v6(64.96,20.76) 64.51,20.31 64.51,17.58 C173.1 64.61,17.48 65.14,16.95 v6(65.26,16.95) ; C177.1 90.42,19.05 95.03,19.05 96.1,17.99 99.11,17.99 C176.1 99.04,17.1 v6(98.71,17.1)
  IN2 w0.508: v6(77.61,27.64) 82.36,22.89 92.92,22.89 v6(98.71,17.1)
  BOTTOM w0.381: v6(87.54,16.95) 87.14,17.34 86.98,17.34 U24.H1 ; v6(76.36,17.23) 76.34,17.24 75.93,17.24 U23.H1 ; v6(65.26,16.95) 65.14,16.95 64.74,17.35 64.65,17.35 U22.H1 ; U25.H1 98.43,17.09 98.71,17.09 v6(98.71,17.1)
+USB0_SIDE_PWR:
  vias: v6(204.43,48.59) v6(205.06,48.59) v6(205.72,48.8) v6(206.36,48.8) v6(207.48,38.94) v6(207.48,38.31) v6(208.11,38.94) v6(208.11,38.31) v7(207.96,40.54) v7(209.51,31.48) v7(211.13,30.41) v7(212.66,30.28)
+V_VDDQ_VR: length 53.6
  TOP w0.508: v6(61.3,12.15) 61.41,12.04 R247.2 ; v6(18.5,8.97) 18.91,9.38 R244.2 ; v6(108.75,11.46) 108.01,10.72 104.35,10.72
  IN1 w0.508: v6(108.75,11.46) 109.43,11.46 115.58,17.61 115.58,19.61
  IN3 w0.381: v6(24.34,41.36) 19.77,36.78 19.77,33.23 20.79,32.21 20.79,30.41 16.7,26.32 14.19,26.32 v6(12.68,24.8)
  BOTTOM w0.254: v6(49.69,42.04) 49.31,42.04 U16.AR48 ; U16.AN33 57.99,43.5 57.74,43.75 57.74,45.85 57.99,46.1 U16.AJ33 ; v6(52.59,45.12) 52.59,43.06 52.38,42.85 U16.AP43 ; U17.5 24.49,42.01 24.34,41.86 C259.1
  BOTTOM w0.381: C259.1 23.72,41.6 23.96,41.36 v6(24.34,41.36)
  vias: v3(115.42,20.33) v3(115.75,20.33) v4(115.42,20.33) v4(115.75,20.33) v6(55.38,36.38) v6(55.38,35.74) v6(55.38,35.11) v6(55.64,47.14) v6(56.04,36.38) v6(56.04,35.74) v6(56.04,35.11) v6(58.24,47.14) v6(59.54,47.14) v6(63.43,46.76) v6(97.34,9.58) v6(98.08,10.24) v6(98.08,9.61) v6(98.77,10.24) v6(98.77,9.58) v7(23.2,24.64) v7(25.56,7.12) v7(48.93,24.95) v7(49.34,7.8) v7(64.53,7.29) v7(68.69,24.95) v7(76.51,7.24) v7(90.36,7.19) v7(98.77,27.51) v7(101.97,28.94)
+VCHGR:
  vias: v7(117.18,16.44) v10(115.02,13.92) v10(115.02,13.16)
+VCHGR_IN:
  vias: v6(129.46,22.29) v6(129.46,21.52) v6(129.46,20.76) v7(130.67,20.1)
AC_OFF: length 16.3
  TOP w0.127: PQ10.2 134.3,35.37 v4(135.12,35.37) ; v4(134.33,47.58) 134.63,47.88 v7(134.63,48.44) 134.45,48.62 R99.2
  IN1 w0.089: v4(135.12,35.37) 135.12,38.02 134.58,38.56 134.58,42.63 133.28,43.92 133.28,45.39 134.33,46.44 v4(134.33,47.58)
AC_PRESENT: length 73.8
  TOP w0.127: v4(90.08,46.28) 89.98,46.18 v7(89.27,46.18) 88.71,46.18 87.56,47.32 R115.1 ; U4.A1 v4(134.04,59.98)
  IN1 w0.089: v4(90.08,46.28) 90.08,46.54 90.51,46.97 v5(90.51,47.52) 90.51,47.53 91.04,47.53 94.37,50.86 102.52,50.86 103.17,51.51 106.95,51.51 107.52,52.08 115.81,52.08 116.44,52.71 120.63,52.71 123.17,55.25 123.55,55.25 124.01,55.71 124.01,56.09 125.21,57.28 125.58,57.28 126.88,58.58 129.7,58.58 130.35,59.22 130.98,59.22 131.74,59.98 v4(134.04,59.98)
  IN3 w0.089: v2(73.43,45.85) 73.43,46.14 73.64,46.36 75.37,46.36 75.43,46.42 75.87,46.42 76.07,46.61 79.31,46.61 79.41,46.72 80.78,46.72 81.9,47.83 83.9,47.83 84.69,47.05 88.17,47.05 88.65,47.52 v5(90.51,47.52)
ACAV_IN: length 195.8
  TOP w0.127: PQ32.2 10.3,16.18 12.15,18.04 v6(12.15,18.8) ; D12.1 136.23,47.2 134.2,47.2 v4(133.82,47.58) ; PR98.1 PR102.2 130.9,33.1 130.47,32.68 PU12.5 ; PR98.1 131.48,34.12 v7(131.02,33.66) ; PR98.1 v4(132.61,34.69) ; v4(119.16,49.05) 119.16,53.6 119.47,53.91 121.55,53.91 Q5.2
  IN1 w0.089: v5(133.74,48.57) 133.82,48.49 v4(133.82,47.58) 133.82,46.77 132.93,45.88 132.93,43.77 134.29,42.4 134.29,35.15 133.74,34.6 133.31,34.6 133.22,34.69 v4(132.61,34.69) 132.61,34.57 133.56,33.61 133.56,33.1 134.33,32.34 134.33,29.24 132.34,27.26 130.11,27.26 v9(129.04,26.19) ; v6(12.15,18.8) 14.56,21.21 47.53,21.21 v9(49.11,19.64) ; v5(118.58,48.52) 119,48.94 119.05,48.94 v4(119.16,49.05)
  IN2 w0.089: v9(129.04,26.19) 128.86,26.19 124.27,21.6 121.07,21.6 119.52,20.05 111.8,20.05 110.09,18.34 110.09,17.51 109.48,16.9 107.91,16.9 105.78,19.02 100.69,19.02 99.02,17.36 99.11,17.26 99.11,16.93 98.88,16.7 98.61,16.7 98.61,16.39 92.87,22.13 81.54,22.13 81.04,22.64 71.74,22.64 71.23,22.13 59.17,22.13 57.81,20.77 53.21,20.77 52.08,19.64 v9(49.11,19.64)
  IN3 w0.089: v5(133.74,48.57) 133.21,48.57 131.71,50.07 120.13,50.07 v5(118.58,48.52)
ACZ_SPKR: length 161.6
  TOP w0.127: v9(55.98,21.97) 55.6,22.36 47.98,22.36 47.46,22.88 40.46,22.88 39.1,24.24 17.66,24.24 v7(16.7,25.2) 16.26,25.2 11.14,30.33 11.14,35.29 13.23,37.38 17.7,37.38 19.19,35.89 v6(19.19,35.59)
  IN1 w0.089: v9(96.02,24.24) 96.02,24.24 96.02,31.25 96.33,31.55 v9(96.33,33.58)
  IN2 w0.089: v9(96.33,33.58) 95.92,33.99 95.92,35.87 94.68,37.11 93.1,37.11 92.16,38.05 90.61,38.05 90.46,37.9 86.57,37.9 85.94,37.27 81.56,37.27 79.57,39.25 75.85,39.25 74.86,40.24 74.86,41.27 75.02,41.42 75.02,42.68 74.58,43.11 74.43,43.11 73.92,43.62 73.92,45.32 73.29,45.95 73.29,47.12 73.49,47.32 74.51,47.32 75.02,47.83 76.46,47.83 78.14,49.51 v5(78.14,50.68) ; v9(55.98,21.97) 56.31,21.65 57.61,21.65 60.07,24.11 71.36,24.11 75.65,28.4 78.22,28.4 81.27,25.35 94.91,25.35 v9(96.02,24.24)
  IN4 w0.089: v2(78.7,51.13) 78.5,51.13 78.14,50.78 v5(78.14,50.68)
  BOTTOM w0.127: v2(78.7,51.13) 77.68,51.13 77.36,51.45 U16.V2 ; CN3.47 19.4,35.8 v6(19.19,35.59)
ALS_EN_R: length 4.7
  TOP w0.127: v7(194.52,28.05) 193.95,28.62 PR113.1 PR112.1 192.93,28.87 191.71,27.64 PU14.3
ALS_INT: length 60.6
  TOP w0.127: v9(139.53,60.91) 139.41,60.91 139.01,60.52 U4.A9
  IN2 w0.089: v5(188.12,56.06) 187.67,56.52 182.33,56.52 181.29,55.48 176.92,55.48 175.73,56.67 175.07,56.67 173.9,57.84 171.33,57.84 170.95,57.46 159.17,57.46 158.38,56.67 148.6,56.67 145.81,59.47 145.81,60.32 145.19,60.94 139.56,60.94 v9(139.53,60.91)
  IN4 w0.089: v5(188.12,56.06) 190.71,53.48 192.08,53.48 v2(192.36,53.2)
  BOTTOM w0.127: J1.21 192.35,53.19 v2(192.36,53.2)
ALS_PWR_EN: length 135.4
  TOP w0.127: PR113.2 193.95,30.83 193.51,31.27 v7(190.15,31.27) 189.27,31.27 188.33,32.21 v4(186.9,32.21)
  IN1 w0.089: v5(185.02,32.29) 186.83,32.29 v4(186.9,32.21)
  IN3 w0.089: v8(180.65,32.34) 180.65,38.46 179.54,39.58 168.92,39.58 164.67,43.83 164.67,43.83 164.51,43.99 164.51,43.99 164.08,44.42 163.66,44.42 160.9,47.17 160.17,47.17 160.17,47.18 155.73,47.18 155.5,46.94 145.23,46.94 141.41,43.12 136.5,43.12 135.65,42.27 130.97,42.27 129.47,43.77 115.21,43.77 111.48,47.5 103.39,47.5 101.38,49.51 92.68,49.51 91.53,48.35 84.23,48.35 84.07,48.52 81.05,48.52 80.27,47.74 v2(80.27,47.73)
  IN4 w0.089: v8(180.65,32.34) 181.26,31.73 184.46,31.73 v5(185.02,32.29)
  BOTTOM w0.076: v2(76.71,47.04) 77.03,47.35 77.48,47.35 77.59,47.46 78.72,47.46
  BOTTOM w0.127: 78.72,47.46 78.89,47.29 79.92,47.29 80.27,47.64 v2(80.27,47.73)
ALW_ON: length 54
  TOP w0.127: v9(129.37,61.04) 129.02,61.04 128.86,60.89 Q4.2 ; v9(141.84,65.84) 141.51,65.84 141.18,65.51 141.18,64.9 141.28,64.8 141.28,63.25 140.95,62.92 140.34,62.92 140.22,62.79 140.22,60.27 U4.A12 142.45,61.92 142.45,62.18 143.55,63.28 145.65,63.28 145.88,63.51 146.3,63.51 146.57,63.24 146.57,62.77 145.65,61.85 145.65,61.1 145.95,60.8 145.95,60.13 146.56,59.51 146.55,59.5 146.55,59.13 146.69,58.98 146.69,57.23 v7(147.2,56.72) 147.56,56.37 147.56,54.79 148.93,53.42 148.93,51.11 148.09,50.27 148.09,48.49 149.03,47.55 149.03,45.37 149.46,44.94 PQ7.5
  IN2 w0.089: v9(129.37,61.04) 129.37,62.08 133.59,66.29 138.6,66.29 138.84,66.53 141.15,66.53 v9(141.84,65.84)
APWROK: length 16.7
  TOP w0.127: v7(87.77,49.48) 87.47,49.78 87.47,50.26 87.24,50.49 R406.2 86.77,50.49 85.95,49.68 R103.2 85.76,49.36 85.56,49.15 v4(85.48,49.15) 85.48,49.23 85.23,49.48 R102.1
  IN1 w0.089: v4(85.48,49.15) 84.77,49.15 84.41,48.8 83.19,48.8 82.69,48.29 81.67,48.29 80.73,49.23 77.23,49.23 76.72,49.74 75.57,49.74 75.3,50.01 v5(75.08,50.01)
  IN4 w0.089: v2(75.4,49.79) 75.18,50.01 v5(75.08,50.01)
  BOTTOM w0.127: v2(75.4,49.79) 75.38,49.76 U16.AB5
AUD_SPK_R+: length 228.9
  TOP w0.762: 88.81,24.06 88.42,24.06 86.87,25.61 59.74,25.61 59.19,26.16 58.6,26.75 52.17,26.75 51.18,27.74 42.09,27.74 41.07,28.76 v7(32.22,28.76) 28.88,28.76 27.81,29.82 24.89,29.82 20.78,33.94 17.27,33.94 16.55,34.66
  IN1 w1.016: 90.46,24.29 92.04,24.29 96.33,19.99 99.96,19.99 102.17,17.79 102.17,13.22 105.58,9.81 115.62,9.81 116.41,10.6 129.71,10.6 130.55,9.75 168.89,9.75 170.11,10.98 175.04,10.98 178.39,14.33 189.25,14.33 191.05,12.53 195.83,12.53 199.67,16.36 207.83,16.36 212.84,21.37 212.84,26.18 217.66,31 217.66,33 217.23,33.43
  vias: v3(89.42,24.26) v3(89.42,23.96) v3(89.72,24.26) v3(89.72,23.96) v3(90,24.26) v3(90,23.96) v4(89.42,24.26) v4(89.42,23.96) v4(89.72,24.26) v4(89.72,23.96) v4(90,24.26) v4(90,23.96) v6(16.22,35.23) v6(216.44,34.68) v6(216.8,34.14)
AUD_SPK_R+_C:
  vias: v6(215.71,32.36)
AUD_SPK_R-: length 234.7
  TOP w0.762: 16.06,33.71 16.85,32.92 20.36,32.92 24.47,28.81 27.39,28.81 28.46,27.74 v7(34.12,27.74) 40.65,27.74 41.67,26.73 50.76,26.73 51.75,25.73 58.18,25.73 59.32,24.59 86.45,24.59 88,23.04 88.78,23.04
  IN1 w1.016: 90.43,22.08 91.37,22.08 95.49,17.96 99.12,17.96 100.14,16.95 100.14,12.38 104.74,7.78 116.46,7.78 117.25,8.56 128.86,8.56 129.71,7.72 169.73,7.72 170.96,8.95 175.88,8.95 179.23,12.3 188.41,12.3 190.21,10.49 196.67,10.49 200.51,14.33 208.67,14.33 214.87,20.53 214.87,25.34 219.69,30.16 219.69,33.91 218.5,35.11
  vias: v3(89.49,23.17) v3(89.49,22.81) v3(89.8,23.17) v3(89.8,22.81) v3(90.1,23.17) v3(90.1,22.84) v4(89.49,23.17) v4(89.49,22.81) v4(89.8,23.17) v4(89.8,22.81) v4(90.1,23.17) v4(90.1,22.84) v6(15.2,35.23) v6(214.39,35.54) v6(214.94,35.87)
AUD_SPK_R-_C:
  vias: v6(214.44,32.36)
AUDIO_ALW: length 108.4
  TOP w0.508: R472.2 R471.2 101.56,19.51 100.92,20.15 96.99,20.15 96.3,20.83 87.5,20.83 85.64,22.69 59.62,22.69 57.57,20.63 47,20.63 46.47,21.16 39.75,21.16 38.41,22.5 15.57,22.5 15.56,22.5 15.22,22.5 14.94,22.5 14.94,22.51 14.93,22.51 14.71,22.73 14.71,22.76 13.34,24.13 13.34,26.44 11.14,28.65 v6(11.14,29.09)
  BOTTOM w0.305: CN3.14 16.4,32.27 16.09,31.96
  BOTTOM w0.508: 16.09,31.96 15.71,31.58 15.71,31.57 15.34,31.2 15.33,31.2 15.28,31.15 EC68.1 15.28,29.73 14.74,29.19 11.24,29.19 v6(11.14,29.09)
AUDIO_EN: length 99.4
  TOP w0.127: Q22.2 99.93,15.48 102.44,17.99 103.41,17.99 104.19,18.76 105,18.76 105.55,19.31 105.55,20.88 104.61,21.82 103.54,21.82 101.94,23.42 101.41,23.42 101.05,23.78 101.05,27.03 101.05,27.03 101.05,27.34 101.15,27.44 101.15,28.76 v4(101.1,28.81)
  IN1 w0.089: v5(100.87,29.8) 100.42,29.8 99.91,29.29 v4(99.91,28.78) 100.01,28.68 100.97,28.68 v4(101.1,28.81) ; v5(103.39,55.55) 103.26,55.55 102.47,56.34 92.12,56.34 91.62,55.83 v5(85.63,55.83)
  IN3 w0.089: v5(85.63,55.83) 85.89,55.83 v2(85.96,55.91) ; v2(113.9,54.35) 113.23,55.02 103.92,55.02 v5(103.39,55.55)
  IN4 w0.089: v2(100.44,29.8) v5(100.87,29.8)
  BOTTOM w0.127: v2(100.44,29.8) 100.44,30.59 104.38,34.52 108.47,34.52 117.13,43.18 117.13,50.17 116.29,51.01 116.29,53.25 115.19,54.35 v2(113.9,54.35) ; U16.P1 78.9,53.74 81.16,56.01 TP77.1 82.2,56.01 R281.1 83.3,55.74 84.16,55.74 84.46,56.04 84.67,56.04 84.68,56.02 84.69,56.02 84.79,55.92 85.95,55.92 v2(85.96,55.91)
AUX_SINK_N_R: length 18.2
  TOP w0.14: U2.6 v4(197.75,57.64)
  IN1 w0.127: 201.18,59.1 201.3,59.22 204.31,59.22 204.66,59.57 205.27,59.57 205.74,60.04 207.23,60.04 v5(207.39,59.88) ; 201.18,59.1 v4(201.18,56.34) ; 201.18,59.1 201.07,59.22 197.87,59.22 197.75,59.1 v4(197.75,57.64)
  IN4 w0.127: v2(207.78,59.88) v5(207.39,59.88)
  BOTTOM w0.14: v2(207.78,59.88) 207.94,60.04 208.28,60.04 208.52,59.8 CN1.18
AUX_SINK_P_R: length 18.2
  IN1 w0.127: v5(207.39,60.57) 207.19,60.37 205.6,60.37 205.13,59.9 204.52,59.9 204.17,59.55 201.31,59.55 201.18,59.68 ; 201.18,59.68 201.06,59.55 197.88,59.55 197.75,59.68 v4(197.75,62.44) ; 201.18,59.68 v4(201.18,62.44)
  IN4 w0.127: v2(207.78,60.57) v5(207.39,60.57)
  BOTTOM w0.14: v2(207.78,60.57) 208.04,60.3 208.35,60.3 208.44,60.4 CN1.16
BAT_LED_WHITE: length 103.4
  TOP w0.127: EC23.1 193.51,18.8 v6(193.85,18.45) 193.35,17.96 v7(193.35,17.94) ; U4.N5 137.01,53.06 136.74,52.79 v9(136.74,52.38)
  IN1 w0.089: v9(131.71,34.5) 131.71,36.83 132.22,37.34 132.22,46.05 132.98,46.82 132.98,48.01 131.96,49.03 131.96,50.8 v9(132.27,51.11)
  IN2 w0.089: v9(132.27,51.11) 132.37,51.21 133.51,51.21 134.07,51.77 134.55,51.77 135.06,52.28 136.64,52.28 v9(136.74,52.38) ; v6(193.85,18.45) 191.65,20.65 188.33,20.65 188.17,20.81 182.2,20.81 181.09,19.69 179.97,19.69 179.16,20.5 179.16,21.44 168.89,31.7 167.19,31.7 166.41,30.92 155.45,30.92 154.95,31.42 154.95,32.19 153.03,34.1 145.56,34.1 142.02,30.56 133.74,30.56 131.71,32.59 v9(131.71,34.5)
  BOTTOM w0.127: v6(193.85,18.45) CN6.4
BAT_LED_YELLOW: length 108.3
  TOP w0.127: v6(194.85,18.45) 194.65,18.65 EC24.1
  IN1 w0.089: v9(131.28,34.5) 131.28,36.81 131.96,37.49 131.96,46.44 132.67,47.15 132.67,47.88 131.76,48.8 131.76,51.44 131.38,51.82 131.38,52.18 131.56,52.35 131.81,52.35 133.51,50.65 135.7,50.65 136.12,51.07 136.12,51.37 135.62,51.87 135.62,53.57 135.77,53.73 135.93,53.73 136.23,54.03 136.74,54.03 137.01,54.3 v4(137.01,54.48)
  IN2 w0.089: v6(194.85,18.45) 194.38,17.99 193.63,17.99 193.38,18.24 193.38,18.5 192.29,19.59 181.65,19.59 181.44,19.38 179.97,19.38 178.95,20.4 178.95,21.16 168.67,31.45 167.27,31.45 166.54,30.72 155.38,30.72 154.62,31.48 154.62,32.24 152.94,33.91 145.66,33.91 142.11,30.36 133.49,30.36 131.28,32.57 v9(131.28,34.5)
  BOTTOM w0.127: CN6.3 v6(194.85,18.45)
BBS: length 17.2
  TOP w0.127: R37.1 R44.2 83.77,58.24 83.4,57.87 82.37,57.87 R43.1 81.49,58.5 80.68,59.31 v7(80.68,59.72) v4(79.72,60.69)
  IN1 w0.089: v5(79.33,60.81) 79.59,60.81 v4(79.72,60.69)
  IN3 w0.089: v2(74,58.73) 76.21,58.73 78.29,60.81 v5(79.33,60.81)
  BOTTOM w0.127: U16.L8 73.64,55.38 74,55.73 v2(74,58.73)
BEEP: length 188
  TOP w0.127: v6(19.14,34.83) 18.63,35.34 18.63,35.89 17.52,37 13.43,37 11.52,35.08 11.52,30.48 16.22,25.79 17.56,25.79 v7(18.12,25.23) 18.7,24.64 39.24,24.64 40.62,23.26 47.61,23.26 48.14,22.74 55.88,22.74 v9(56.62,22) ; U4.K7 138.01,55.37 138.17,55.21 v9(138.17,55.16)
  IN1 w0.089: v5(136.15,37.75) 136.15,37.6 136.41,37.34 136.41,29.72 132.8,26.12 v9(130.9,26.12)
  IN2 w0.089: v9(138.17,55.16) 138.17,53.16 137.52,52.52 137.52,52.05 137.4,51.92 134.99,51.92 134.5,51.44 134.27,51.44 v5(134.05,51.21) ; v9(130.9,26.12) 130.9,26.34 130.49,26.75 128.61,26.75 123.83,21.97 120.95,21.97 120.64,21.65 119.37,20.39 111.65,20.39 111.36,20.68 100.11,20.68 98.85,21.94 98.85,23.26 96.39,25.71 81.52,25.71 78.48,28.74 75.23,28.74 71.03,24.54 60.02,24.54 57.48,22 v9(56.62,22)
  IN4 w0.089: v2(133.56,51.06) 133.89,51.06 v5(134.05,51.21) ; v2(135.87,38.05) 136.15,37.77 v5(136.15,37.75)
  BOTTOM w0.127: v6(19.14,34.83) 19.14,35.01 18.67,35.48 18.67,35.7 18.9,35.94 CN3.46 ; v2(133.56,51.06) 133.56,38.89 134.4,38.05 v2(135.87,38.05)
BID0: length 7.2
  TOP w0.127: v9(140.12,56.47) 140.12,56.62 139.94,56.8 139.69,56.8 U4.G10 ; v6(143.19,55.66) 143.16,55.63 v9(143.16,55.15) 143.77,55.15 143.82,55.2 R66.1 R73.2
  IN2 w0.089: v9(140.12,56.47) 140.21,56.57 141.75,56.57 v9(143.16,55.15)
BLED0: length 118.2
  TOP w0.127: U4.D13 141.22,58.48 143.04,60.3 143.04,61.55 142.91,61.68 142.91,61.96 143.9,62.95 146.01,62.95 v4(146.13,63.06)
  IN1 w0.089: v9(151.09,40.97) 151.09,41.23 146.81,45.51 146.81,50.84 147.76,51.79 147.76,54.59 148.45,55.27 148.45,59.34 147.39,60.39 147.39,61.71 146.42,62.69 146.42,62.78 v4(146.13,63.06)
  IN2 w0.089: v9(151.09,40.97) 151.55,41.43 154.95,41.43 155.2,41.18 159.29,41.18 160.06,40.42 173.24,40.42 173.67,39.98 174.33,39.98 177.17,37.14 179.23,37.14 182.05,39.96 189.57,39.96 190.21,39.32 202.8,39.32 205.85,36.28 219.21,36.28 220.74,34.74 220.74,31.13 v5(221.31,30.56)
  IN4 w0.089: v5(221.31,30.56) 221.32,30.57 v2(221.32,30.94)
  BOTTOM w0.127: Q31.2 220.28,29.77 219.8,29.3 R371.1 C268.1 219.89,30.55 v7(220.46,31.12) 221.14,31.12 v2(221.32,30.94)
BLED1: length 118.7
  TOP w0.127: U4.D6 v9(137.61,58.48)
  IN1 w0.089: v5(209.36,23.75) 208.14,24.97 203.54,24.97 201.38,27.13 201.38,28.91 197.51,32.78 197.51,38.14 195.82,39.83 195.82,43.01 193.51,45.32 193.51,45.6 192.3,46.8 192.02,46.8 190.38,48.44 v9(190.38,56.06)
  IN2 w0.089: v9(190.38,56.06) 190.1,55.78 189.29,55.78 188.15,56.93 182.1,56.93 181.05,55.87 177.09,55.87 175.88,57.08 175.37,57.08 174.2,58.25 158.53,58.25 157.77,57.48 149.79,57.48 146.77,60.51 146.77,61.45 146.39,61.83 139.84,61.83 139.53,62.13 139.28,62.13 138.87,61.73 137.93,61.73 137.61,61.4 v9(137.61,58.48)
  IN4 w0.089: v5(209.36,23.75) 211.08,25.48 215.22,25.48 215.47,25.73 v2(219.59,25.73)
  BOTTOM w0.127: Q33.2 220.76,25.61 221.36,26.21 C273.1 220.56,26.5 v6(220.41,26.34) 219.79,25.73 v2(219.59,25.73)
BLED2: length 137
  TOP w0.127: U4.G1 134.32,56.98 133.36,57.94 v4(133.36,58.02)
  IN1 w0.089: v5(209.71,22.94) 209.81,23.05 209.81,24.03 208.49,25.35 204.3,25.35 203.03,26.62 203.03,35.77 202.24,36.56 202.24,38.05 201.79,38.51 201.79,39.48 202.52,40.21 202.52,42.05 201.44,43.13 201.44,47.57 199.18,49.83 199.18,52.49 198.38,53.29 197.44,53.29 193.36,57.38 v9(192.11,57.38) ; v9(131.91,58.12) 133.31,58.12 133.41,58.02 v4(133.36,58.02)
  IN2 w0.089: v9(131.91,58.12) 131.91,60.28 131.43,60.76 131.43,63.74 133.74,66.05 139.04,66.05 139.38,65.71 141.28,65.71 141.44,65.56 145.63,65.56 146.39,66.32 151,66.32 152.85,64.47 152.85,63.49 156.63,59.72 174.18,59.72 175.8,58.09 176.26,58.09 176.98,57.38 179.89,57.38 180.22,57.71 188.78,57.71 189.11,57.38 v9(192.11,57.38)
  IN4 w0.089: v5(209.71,22.94) 216.34,22.94 219.38,19.9 v2(219.54,19.9)
  BOTTOM w0.127: Q34.2 220.05,21.26 219.94,21.15 R387.1 ; v2(219.54,19.9) R387.1 ; R387.1 218.7,21.15 v7(218.63,21.09)
BLED3: length 130.8
  TOP w0.127: v4(140.04,51.52) 139.79,51.77 138.44,51.77 137.65,52.56 v9(137.08,52.56) ; v9(137.79,56.31) 137.51,56.03 U4.J6
  IN1 w0.089: v4(140.04,51.52) 140.24,51.31 140.24,49.2 140.42,49.03 140.42,41.99 142.94,39.48 143.7,39.48 148.9,34.27 148.9,31.63 150.37,30.16 150.37,26.01 150,25.63 150,19.56 149.72,19.28 149.72,17.81 150.23,17.3 v5(150.76,17.3)
  IN2 w0.089: v9(137.08,52.56) 137.08,52.6 137.63,53.15 137.63,55.65 137.79,55.81 v9(137.79,56.31)
  IN3 w0.089: v5(150.76,17.3) 150.86,17.2 160.92,17.2 161.96,16.16 165.11,16.16 166.2,15.07 172.48,15.07 173.36,15.96 181.82,15.96 184.74,18.87 184.74,21.21 185.78,22.25 193.42,22.25 194.09,22.92 196.49,22.92 198.7,25.13 203.54,25.13 204.51,24.16 v6(205.37,24.16)
  BOTTOM w0.127: C280.1 R394.1 219.8,15.71 219.97,15.88 Q35.2 217.15,16.44 216.68,16.91 216.68,18.31 v7(215.48,19.51) 212.43,22.56 206.97,22.56 v6(205.37,24.16)
BLED4: length 121.4
  TOP w0.127: v7(220.56,16.21) 220.55,16.22 R232.2 219.16,17.1 218.77,16.71 C180.1 218.77,15.34 Q20.2 217.26,15.9 217.26,17.1 213.67,20.68 v4(210.58,20.68) ; U4.A5 137.12,60.09 137.12,60.31 v9(137.13,60.32)
  IN1 w0.089: v4(210.58,20.68) 208.18,23.08 208.18,23.89 207.35,24.72 203.34,24.72 201,27.06 201,28.86 197.09,32.77 197.09,38.06 195.46,39.68 195.46,41.58 191.91,45.14 191.91,46.41 189.98,48.35 v9(189.98,56.06)
  IN2 w0.089: v9(189.98,56.06) 189.44,56.06 188.38,57.13 182.03,57.13 180.98,56.09 177.15,56.09 175.96,57.28 175.45,57.28 174.28,58.45 158.43,58.45 157.66,57.68 149.9,57.68 147,60.58 147,61.52 146.49,62.03 139.91,62.03 139.63,62.32 139.18,62.32 138.8,61.93 137.5,61.93 137.23,61.66 137.23,60.44 137.13,60.34 v9(137.13,60.32)
BLED_SW_IN0#: length 151.7
  TOP w0.127: SW1.1 220.89,29.85 220.05,30.69 220.05,35.56 219.21,36.4 v7(217.43,36.4) 212.02,36.4 v4(210.96,37.47) ; D2.3 120.61,62.92 120.79,63.1 v9(121.52,63.1)
  IN1 w0.089: v9(209.41,57.28) 209.41,55.43 204.48,50.5 204.48,49.86 203.44,48.82 203.44,43.36 204.05,42.75 204.05,39.73 206.31,37.47 v4(210.96,37.47)
  IN2 w0.089: v9(209.41,57.28) 209.36,57.33 209.36,63.81 207.2,65.97 204.18,65.97 202.52,64.32 197.98,64.32 195.16,61.5 189.72,61.5 188.55,62.67 188.55,63.71 187.18,65.08 174.74,65.08 174,65.82 168.09,65.82 165.41,63.14 155.24,63.14 151.34,67.04 138.81,67.04 138.54,66.77 132.46,66.77 131.64,65.95 125.29,65.95 123.17,63.83 122.26,63.83 v9(121.52,63.1)
BLED_SW_IN0#_R: length 18.1
  TOP w0.127: U4.A3 136.01,60.4 135.69,60.71 133.13,60.71 v6(132.37,61.47) 132.12,61.73 v4(131.91,61.73) ; R47.1 121.25,59.91 v9(121.27,59.92)
  IN1 w0.089: v9(126.84,59.76) 127.41,60.33 129.07,60.33 129.91,61.17 130.79,61.17 131.15,61.52 131.71,61.52 v4(131.91,61.73)
  IN2 w0.089: v9(126.84,59.76) 126.7,59.9 121.29,59.9 v9(121.27,59.92)
BT_PCMCLK: length 2.9
  TOP w0.127: v6(181.67,35.98) 182.15,35.5 182.15,35.3 182.34,35.11 U11.2
  BOTTOM w0.127: v6(181.67,35.98) 181.34,35.65 CN4.8
BT_PCMFR1: length 2.8
  TOP w0.127: v6(181.67,35.32) 181.67,35.03 181.99,34.71 U11.3
  BOTTOM w0.127: CN4.10 181.26,35.15 181.38,35.28 181.62,35.28 v6(181.67,35.32)
BT_PCMIN: length 3.8
  TOP w0.127: v6(181.87,33.7) 182.09,33.91 U11.5
  BOTTOM w0.127: CN4.12 181.3,34.65 181.49,34.84 181.84,34.84 182.15,34.52 182.15,33.98 v6(181.87,33.7)
BT_PCMOUT: length 3.3
  TOP w0.127: v7(180.81,34.24) 181.61,34.24 v6(181.7,34.33) 181.72,34.31 U11.4
  BOTTOM w0.127: CN4.14 181.51,34.15 v6(181.7,34.33)
BT_RADIO_DIS#: length 137.8
  TOP w0.127: R113.1 79.59,47.45 79.46,47.32 v9(78.83,47.32)
  IN1 w0.089: v9(180.76,43.24) 181.14,42.85 181.14,39.35 177.89,36.1 177.89,31.75 181.09,28.55 v4(181.09,23.73)
  IN2 w0.089: v9(180.76,43.24) 180.2,43.79 175.75,43.79 174.63,42.68 166.79,42.68 166.35,43.11 163.18,43.11 162.77,43.51 155.31,43.51 154.8,43.01 146.31,43.01 143.67,40.37 141.51,40.37 141.06,39.91 137.78,39.91 137.22,40.47 132.55,40.47 131.81,39.73 124.55,39.73 124.19,40.09 117.51,40.09 117.38,39.96 107.71,39.96 105.78,41.89 105.78,43.29 104.94,44.12 95.59,44.12 95.16,43.69 90.94,43.69 90.54,44.1 88.35,44.1 85.73,46.72 79.86,46.72 79.26,47.32 v9(78.83,47.32) 78.65,47.15 75.52,47.15 v5(75.18,46.8)
  IN4 w0.089: v2(74.84,46.8) v5(75.18,46.8)
  BOTTOM w0.127: U16.AG6 v2(74.84,46.8)
BT_RADIO_DIS#_R: length 8.9
  TOP w0.127: v6(181.9,24.97) 181.16,25.71 Q13.3 ; v6(181.9,24.97) 182.24,24.63 184.25,24.63 v7(184.52,24.36) ; v6(181.9,24.97) 181.9,24.14 182.7,23.33 R215.1
  BOTTOM w0.127: CN4.54 181.42,24.15 181.9,24.63 v6(181.9,24.97)
BT_WAKE#: length 131.9
  TOP w0.127: R171.2 180.69,33.07 181.54,32.21 v6(182.06,32.21)
  IN1 w0.089: v5(93.43,45.41) 93.43,45.52 94.85,46.94 94.85,48.39 95.44,48.98 96.1,48.98 96.86,48.21 103.03,48.21 104.32,49.5 112.32,49.5 112.66,49.84 115.25,49.84 115.73,49.36 v5(115.73,48.68)
  IN3 w0.089: v6(182.06,32.21) 182.61,32.76 182.61,38.08 181.95,38.74 181.95,40.06 180.46,41.55 180.34,41.55 180.11,41.77 178.83,41.77 178.6,41.55 169.44,41.55 165.05,45.94 165.05,47.49 162.49,50.04 158.86,50.04 158.53,50.37 148.43,50.37 148.19,50.13 142.36,50.13 141.44,49.2 134.88,49.2 133.89,48.21 132.98,48.21 131.38,49.81 120.48,49.81 118.81,48.14 116.28,48.14 v5(115.73,48.68) ; v5(93.43,45.41) 93.43,45.43 93.19,45.19 91.88,45.19 91.81,45.27 v2(87.61,45.27) 83.02,45.27 81.87,44.12 81.42,44.12 80.9,44.64 78.07,44.64 77.91,44.48 77.67,44.48 v2(77.12,45.03)
  BOTTOM w0.127: U16.AM3 76.83,44.04 77.04,44.25 77.04,44.85 77.09,44.9 77.09,45 v2(77.12,45.03) ; v2(87.61,45.27) 87.84,45.27 TP111.1 88.22,45.65 88.4,45.65 89.23,46.48 R323.1
BUF_PLT_RST#: length 157.2
  TOP w0.127: R487.1 177.65,28.74 177.17,29.21 176.62,29.21 176.36,28.96 174.85,28.96 174.29,29.52 ; v4(155.7,60.91) 158.2,60.91 158.56,60.56 159.47,60.56 159.67,60.35 159.67,59.69 159.09,59.11 159.09,58.22 158.85,57.98 R56.2 ; U12.1 174.46,31.49 v7(174.46,30.74) v4(174.46,30.05) 174.46,30.05 174.46,29.69 174.29,29.52 ; U4.M4 136.51,54.47 v9(136.51,54.39) ; U9.4 90.02,38.04 89.9,38.16 v9(89.9,38.84) 89.9,39.8 89.99,39.88 R152.1 89.99,41.58 R142.1 ; 174.29,29.52 U14.1
  IN1 w0.089: v4(155.7,60.91) 155.7,56.33 160.43,51.59 v5(160.43,51.35) 160.83,51.35 160.94,51.46 168.49,51.46 170.37,49.58 170.37,49.21 171.94,47.63 173.22,46.36 173.22,31.29 v4(174.46,30.05)
  IN2 w0.089: v9(89.9,38.84) 90.23,39.17 94.52,39.17 95.64,40.29 96.63,40.29 97.8,41.46 102.4,41.46 103.85,40.01 104.35,40.01 104.73,39.63 104.73,38.94 106.66,37.02 110.28,37.02 110.42,37.16 113.47,37.16 113.95,36.68 117.76,36.68 118.83,37.75 120.78,37.75 121.35,37.18 124.64,37.18 124.93,37.47 133.21,37.47 133.51,37.77 134.57,37.77 v5(134.7,37.9) ; v9(136.52,54.39) 136.41,54.29 136.41,53.15 136.18,52.91 134.58,52.91 v5(134.2,52.53)
  IN4 w0.089: v5(160.43,51.35) 159.81,51.97 154.54,51.97 153.73,52.79 134.81,52.79 v2(134.55,52.53) v5(134.2,52.53) ; v2(134.81,38.69) 134.81,38.01 v5(134.7,37.9)
  BOTTOM w0.127: v2(134.81,38.69) 134.55,38.94 v2(134.55,52.53)
BUF_PLT_RST#_TPM: length 8.4
  TOP w0.127: U6.16 156.32,56.49 156.68,56.85 158.2,56.85 v7(158.33,56.98) 158.33,57.48 158.07,57.74 158.07,58.37 158.46,58.76 R56.1 158.58,59.32 158.99,59.73 v7(158.99,60) 158.4,60 158.13,60.26 U1.4
CAD_SINK#: length 25.9
  TOP w0.127: Q2.2 199.35,66.35 199.72,65.98 199.72,65.63 199.85,65.49 R10.1 200.24,66.12 200.72,66.6 202.73,66.6 203.03,66.3 203.03,64.22 202.48,63.67 U3.1 v6(202.48,61.21)
  IN1 w0.089: v4(201.83,56.34) v5(201.83,56.9)
  IN4 w0.089: v2(206.59,64.98) 205.32,64.98 202.91,62.56 202.91,61.63 v6(202.48,61.21) 201.83,60.56 v5(201.83,56.9)
  BOTTOM w0.127: v2(206.59,64.98) 207.1,64.98 208.08,64 CN1.4
CAP_LED: length 119
  TOP w0.127: Q14.2 158.4,22.15 158.32,22.24 v4(158.32,24.46) 158.32,25.36 v7(158.3,25.38)
  IN1 w0.089: v9(157.03,43.79) 157.9,42.93 157.9,36.83 156.75,35.69 156.75,30.13 157.24,29.65 157.24,25.55 v4(158.32,24.46) ; v4(77.81,52.53) 77.53,52.53 77.11,52.95 v5(76.94,52.95)
  IN2 w0.089: v5(76.94,52.95) 77.09,52.95 77.63,52.4 77.63,51.77 78.24,51.16 78.7,51.16 79.03,50.83 79.03,49.61 81.53,47.11 82.24,47.11 82.43,46.92 85.8,46.92 88.39,44.34 90.66,44.34 91.03,43.97 94.93,43.97 95.46,44.51 104.89,44.51 105.98,43.41 105.98,41.97 107.78,40.16 117.31,40.16 117.43,40.29 124.29,40.29 124.61,39.97 131.57,39.97 132.29,40.7 137.27,40.7 137.87,40.1 140.97,40.1 141.44,40.57 143.6,40.57 146.24,43.21 152.46,43.21 152.59,43.34 154.72,43.34 155.18,43.79 v9(157.03,43.79)
  IN4 w0.089: v2(74.73,53.47) 74.73,53.3 75.35,52.68 76.67,52.68 v5(76.94,52.95)
CAP_LED_L: length 11.4
  TOP w0.127: v4(162.44,18.52) 162.49,18.47 v7(162.49,17.4) 161.53,16.44 159.25,16.44 159.1,16.3 JKB1.27
  IN1 w0.089: v4(162.53,24.46) 162.53,18.6 v4(162.44,18.52)
CATERR#: length 10.4
  IN4 w0.089: v2(40.69,56.07) 40.06,56.7 30.67,56.7 v2(30.57,56.6)
CFG0: length 5.7
  TOP w0.127: R117.1 37.96,46.72 v6(39.08,47.83) v4(39.46,48.21)
  IN1 w0.089: v5(41.69,48.9) 41.69,48.37 41.54,48.21 v4(39.46,48.21)
  IN4 w0.089: v2(41.34,49.25) 41.34,49.25 v5(41.69,48.9)
