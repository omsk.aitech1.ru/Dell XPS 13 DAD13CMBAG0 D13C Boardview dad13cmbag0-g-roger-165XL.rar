# Allegro board dad13cmbag0-g-roger-165XL.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
LPC_LAD0_R: length 8.5
  TOP w0.127: R219.1 186.45,21.16 v6(186.4,21.21) 186.4,21.29 185.94,21.75 v7(185.94,21.77)
  BOTTOM w0.127: v6(186.4,21.21) 184.95,22.66 181.87,22.66 181.38,23.15 CN4.58
LPC_LAD0_TPM: length 2.6
  TOP w0.127: U6.26 149.82,56.98 149.44,57.36 R50.1
LPC_LAD1: length 189.9
  TOP w0.127: R221.2 v6(188.94,20.15) v7(189.44,20.65) ; v9(151.47,60.25) R51.2 ; U4.J2 v9(135.4,55.98)
  IN1 w0.089: v9(135.4,55.98) 134.67,55.98 134.5,55.81 133.32,55.81 132.95,55.43 129.76,55.43 128.84,54.51 127.92,54.51 122.53,49.12 119.91,49.12 117.74,46.94 106.74,46.94 105.37,45.57 101.71,45.57 99.32,43.18 97.01,43.18 95.54,41.71 95.13,41.71 93.5,40.08 93.5,32.23 91.86,30.59 82.56,30.59 77.84,35.31 75.68,35.31 73.9,37.09 72.93,37.09 72.29,36.44 v6(71.94,36.44) ; v9(151.47,60.25) 151.82,60.6 153.69,60.6 154.52,59.78 154.52,55.73 160.16,50.09 164.55,50.09 165.35,49.29 165.35,48.32 166.72,46.95 166.72,46.48 168.2,45 168.2,39.78 169.73,38.25 169.73,35.03 168.28,33.58 168.28,33.15 173.44,27.99 173.44,20.43 176.94,16.93 183.92,16.93 185.42,18.43 185.42,18.89 186.24,19.71 188.5,19.71 v6(188.94,20.15)
  IN2 w0.089: v9(151.47,60.25) 151.34,60.38 151.34,61.17 150.29,62.22 150.29,63.41 149.95,63.75 149.5,63.75 148.65,64.59 146.75,64.59 146,63.83 135.09,63.83 134.15,62.89 134.15,57.23 v9(135.4,55.98)
  BOTTOM w0.089: 71.38,38.43 71.18,38.64 71.18,39.45 70.9,39.74 U16.AW12
  BOTTOM w0.127: 71.38,38.43 71.38,36.97 71.92,36.44 v6(71.94,36.44)
LPC_LAD1_R: length 8
  TOP w0.127: v6(186.4,20.4) 186.65,20.15 R221.1
  BOTTOM w0.127: CN4.60 181.29,22.65 181.54,22.4 184.52,22.4 186.4,20.53 v6(186.4,20.4)
LPC_LAD1_TPM: length 2.5
  TOP w0.127: U6.23 151.77,56.96 151.47,57.26 R51.1
LPC_LAD2: length 190.3
  TOP w0.127: R54.2 154.04,60.25 v9(153.5,60.25) ; v9(134.4,56.12) 134.55,55.98 U4.J1 ; v7(189.47,18.62) 189.44,18.62 v6(188.94,19.13) R224.2
  IN1 w0.089: v9(153.5,60.25) 153.5,56.24 159.99,49.75 163.09,49.75 164.88,47.96 165.2,47.96 166.28,46.88 166.28,46.38 167.85,44.81 167.85,39.4 169.38,37.87 169.38,35.18 167.89,33.7 167.89,33.06 173.06,27.89 173.06,20.17 176.65,16.59 184.23,16.59 186.24,18.6 188.4,18.6 v6(188.94,19.13) ; v9(134.4,56.12) 133.17,56.12 132.85,55.8 129.62,55.8 128.79,54.97 127.87,54.97 122.36,49.46 118.6,49.46 116.43,47.29 106.58,47.29 105.27,45.98 101.61,45.98 99.17,43.54 96.86,43.54 95.39,42.07 94.98,42.07 93.16,40.24 93.16,32.4 91.78,31.02 82.74,31.02 78.1,35.65 75.87,35.65 74.08,37.44 72.73,37.44 72.13,36.84 70.92,36.84 v6(70.67,37.09)
  IN2 w0.089: v9(153.5,60.25) 153.5,60.56 151.32,62.74 151.32,63.84 150.38,64.77 149.64,64.77 149.21,65.21 146.54,65.21 146.01,64.67 138.82,64.67 138.64,64.85 137.93,64.85 137.63,64.55 137.62,64.55 137.5,64.42 136.59,64.42 136.47,64.55 134.76,64.55 133.51,63.3 133.51,56.79 133.91,56.39 134.14,56.39 v9(134.4,56.12)
  BOTTOM w0.127: U16.AY12 70.89,38.49 71.1,38.28 71.1,37.52 v6(70.67,37.09)
LPC_LAD2_R: length 8.7
  TOP w0.127: R224.1 v6(186.4,19.13)
  BOTTOM w0.127: CN4.62 184.29,22.15 185.94,20.5 185.94,19.59 v6(186.4,19.13)
LPC_LAD2_TPM: length 3.4
  TOP w0.127: U6.20 153.72,56.55 154.42,57.26 154.81,57.26 R54.1
LPC_LAD3: length 189.1
  TOP w0.127: R227.2 v6(188.94,18.11) ; U4.H2 v9(135.4,56.48) ; v9(152.49,60.25) 153.02,60.79 154.16,60.79 155.18,59.77 157.06,59.77 157.57,59.26 R55.2
  IN1 w0.089: v9(135.4,56.48) 133.16,56.48 132.83,56.15 129.41,56.15 128.62,55.35 127.75,55.35 122.2,49.8 118.44,49.8 116.27,47.63 106.41,47.63 105.12,46.33 101.28,46.33 98.84,43.9 96.71,43.9 95.23,42.42 94.8,42.42 92.82,40.44 92.82,32.56 91.63,31.37 82.92,31.37 78.29,36 76.03,36 74.2,37.83 72.53,37.83 v6(71.94,37.24) ; v9(152.49,60.25) 152.9,59.84 152.9,56.33 159.83,49.41 162.93,49.41 164.73,47.6 165.07,47.6 165.92,46.75 165.92,46.18 167.51,44.6 167.51,32.96 172.68,27.78 172.68,19.89 176.33,16.24 184.4,16.24 185.61,17.45 188.27,17.45 v6(188.94,18.11)
  IN2 w0.089: v9(135.4,56.48) 134.5,57.38 134.5,62.77 135.32,63.58 146.01,63.58 146.76,64.33 148.41,64.33 149.95,62.79 149.95,62.05 150.94,61.06 150.94,60.25 151.27,59.92 152.16,59.92 v9(152.49,60.25)
  BOTTOM w0.089: 71.66,37.52 71.66,38.56 71.36,38.87 71.36,39.45 U16.AW11
  BOTTOM w0.127: 71.66,37.52 v6(71.94,37.24)
LPC_LAD3_R: length 9.6
  TOP w0.127: R227.1 187.07,17.86 v6(186.4,17.86)
  BOTTOM w0.127: CN4.64 184.36,21.65 185.66,20.35 185.66,18.85 186.4,18.11 v6(186.4,17.86)
LPC_LAD3_TPM: length 3.5
  TOP w0.127: R55.1 157.57,57.74 157.06,57.23 156.5,57.23 155.67,56.4 U6.17
LPC_LFRAME#: length 186
  TOP w0.127: R231.2 v6(188.94,17.1) ; U4.H1 133.94,56.48 133.82,56.6 v9(133.82,56.98) ; R52.2 v9(152.49,59.52)
  IN1 w0.089: v6(70.67,37.72) 71.64,37.72 72.22,38.31 76.54,38.31 78.13,36.72 78.31,36.72 83.19,31.83 91.55,31.83 92.46,32.74 92.46,40.59 94.65,42.78 95.06,42.78 96.56,44.28 98.71,44.28 101.13,46.69 104.96,46.69 106.25,47.97 116.1,47.97 118.43,50.3 121.86,50.3 121.87,50.31 122.07,50.31 128.31,56.54 132.01,56.54 132.12,56.44 132.72,56.44 133.26,56.98 v9(133.82,56.98) ; v9(152.49,59.52) 152.49,56.26 159.7,49.05 162.77,49.05 164.58,47.25 164.93,47.25 165.58,46.6 165.58,46.02 167.11,44.49 167.11,32.87 172.3,27.68 172.3,19.64 176.04,15.9 184.56,15.9 185.25,16.59 188.43,16.59 v6(188.94,17.1)
  IN2 w0.089: v9(133.82,56.98) 133.82,63.07 134.9,64.16 137.52,64.16 137.98,64.62 138.59,64.62 138.85,64.37 145.98,64.37 146.62,65 149.11,65 149.68,64.43 150.24,64.43 150.97,63.69 150.97,62.55 153.04,60.48 153.04,60.08 v9(152.49,59.52)
  BOTTOM w0.089: 70.61,38.61 70.61,39.99 70.85,40.24 U16.AV12
  BOTTOM w0.127: 70.61,38.61 70.61,37.94 70.67,37.88 v6(70.67,37.72)
LPC_LFRAME#_R: length 10.7
  TOP w0.127: v7(185.76,16.72) 186.06,16.72 v6(186.4,17.05) 186.45,17.1 R231.1
  BOTTOM w0.127: v6(186.4,17.05) 186.4,17.1 185.38,18.11 185.38,20.25 184.48,21.15 CN4.66
LPC_LFRAME#_TPM: length 2.4
  TOP w0.127: U6.22 152.41,57.54 152.49,57.61 R52.1
M_A_A0: length 120.3
  TOP w0.089: R412.2 33.57,15.07 33.72,15.07 v7(34.35,14.43) 35.4,13.38 v9(35.4,13.32)
  IN1 w0.076: v5(24.62,14.36) 25.13,13.85 25.97,13.85 26.32,13.49 28.79,13.49 28.86,13.57 28.86,13.85 28.94,13.92 29.09,13.92 29.17,13.85 29.17,13.57 29.24,13.49 29.4,13.49 29.47,13.57 29.47,13.85 29.55,13.92 29.7,13.92 29.78,13.85 29.78,13.57 29.85,13.49 30,13.49 30.08,13.57 30.08,13.85 30.16,13.92 30.31,13.92 30.39,13.85 30.39,13.57 30.46,13.49 30.61,13.49 30.69,13.57 30.69,13.85 30.77,13.92 30.92,13.92 31,13.85 31,13.57 31.07,13.49 31.22,13.49 31.3,13.57 31.3,13.85 31.38,13.92 31.53,13.92 31.6,13.85 31.6,13.57 31.68,13.49 31.83,13.49 31.91,13.57 31.91,13.85 31.99,13.92 32.14,13.92 32.21,13.85 32.21,13.57 32.29,13.49 32.44,13.49 32.52,13.57 32.52,13.85 32.6,13.92 32.75,13.92 32.82,13.85 32.82,13.57 32.9,13.49 33.05,13.49 33.13,13.57 33.13,13.85 33.21,13.92 33.36,13.92 33.43,13.85 33.43,13.57 33.51,13.49 33.77,13.49 34.02,13.24 35.32,13.24 v9(35.4,13.32) 35.41,13.31 41.56,13.31 41.87,13.62 45.17,13.62 45.22,13.67 45.22,14.1 45.3,14.18 45.53,14.18 45.58,14.13 45.58,13.72 45.68,13.62 46.14,13.62 46.24,13.72 46.24,14.15 46.54,14.46 46.54,14.63 46.7,14.79 47.79,14.79 47.89,14.69 47.89,13.92 47.74,13.77 47.25,13.77 46.97,14.05 v5(46.97,14.36)
  IN2 w0.165: v9(35.4,13.32) 35.14,13.32 35.01,13.45 35.01,13.89 34.43,14.47 34.43,17.15 34.87,17.59 34.87,17.98 35.85,18.95 35.85,20.93 45.29,30.37 48.59,30.37 48.79,30.57 48.79,31.86 48.97,32.05 49.23,32.05 49.41,31.86 49.41,30.55 49.6,30.37 49.85,30.37 50.04,30.55 50.04,32.69 50.21,32.87 50.4,32.87 50.61,32.66 50.61,30.54 50.78,30.37 51.02,30.37 51.19,30.54 51.19,32.7 51.36,32.87 51.6,32.87 51.78,32.7 51.78,30.55 51.95,30.37 52.21,30.37 52.38,30.55 52.38,32.7 52.56,32.87 52.8,32.87 52.97,32.7 52.97,32.07 53.15,31.88 53.42,31.88 53.6,32.07 53.6,32.69 53.78,32.87 54.34,32.87 55.62,34.14 56.35,34.14 56.96,34.75 56.96,37.44 56.09,38.31 56.09,40.58 v5(55.97,40.7)
  IN4 w0.076: v2(30.39,13.37) 29.95,13.37 28.61,14.71 24.98,14.71 v5(24.62,14.36) 24.44,14.18 23.99,14.18 23.81,14 23.19,14 23.07,14.13 22.89,14.13 22.76,14 22.58,14 22.46,14.13 22.28,14.13 22.15,14 21.75,14 21.39,13.64 21.28,13.64 21.2,13.72 20.95,13.72 20.87,13.64 20.67,13.64 20.59,13.72 20.34,13.72 20.26,13.64 19.77,13.64 19.69,13.57 19.69,13.39 19.59,13.29 19.3,13.29 v2(19.21,13.37) ; v2(41.56,13.37) 41.65,13.29 42.02,13.29 42.07,13.34 42.07,13.52 42.2,13.64 42.51,13.64 42.59,13.72 42.76,13.72 42.91,13.57 43.09,13.57 43.24,13.72 43.37,13.72 43.52,13.57 43.67,13.57 44.1,14 44.5,14 44.66,14.15 44.81,14.15 44.96,14 45.11,14 45.27,14.15 45.42,14.15 45.57,14 46.16,14 46.34,14.18 46.8,14.18 v5(46.97,14.36) 47.33,14.71 50.96,14.71 52.03,13.64 52.69,13.64 52.79,13.54 52.79,13.42 v2(52.74,13.37)
  IN4 w0.165: v5(55.97,40.7) 55.97,40.73 56.28,41.04 v2(56.47,41.04)
M_A_A1: length 120.6
  TOP w0.089: R417.2 36.41,7.83 v7(35.82,8.41) 35.29,8.95 v9(34.81,8.95)
  IN1 w0.076: v5(22.11,9.94) 22.36,9.68 23.76,9.68 24.22,9.22 29.65,9.22 29.99,8.88 34.07,8.88 34.13,8.95 v9(34.81,8.95) 36.54,8.95 36.71,9.12 43.01,9.12 43.32,9.43 46.01,9.43 46.19,9.61 46.19,9.76 46.01,9.94 v5(44.46,9.94)
  IN2 w0.165: v9(34.81,8.95) 35.7,8.06 35.7,7.19 35.82,7.07 36.29,7.07 36.41,7.19 36.41,8.46 35.32,9.55 35.32,10.75 34.96,11.1 34.96,11.74 34.38,12.32 34.38,12.96 34.7,13.28 34.7,13.68 34.12,14.26 34.12,17.28 34.6,17.76 34.6,18.11 35.49,19 35.49,21.1 44.77,30.37 44.77,31.45 44.94,31.62 45.18,31.62 45.35,31.45 45.35,30.92 45.53,30.74 45.78,30.74 45.96,30.92 45.96,32.63 46.16,32.84 46.39,32.84 46.59,32.63 46.59,30.92 46.77,30.74 47.02,30.74 47.2,30.92 47.2,33.05 47.39,33.23 47.65,33.23 47.84,33.05 47.84,30.91 48.01,30.74 48.25,30.74 48.42,30.91 48.42,33.06 48.6,33.23 48.85,33.23 49.03,33.06 49.03,32.6 49.22,32.41 49.48,32.41 49.67,32.6 49.67,33.03 49.87,33.23 54.19,33.23 55.46,34.51 56.08,34.51 56.55,34.98 56.55,36.85 v5(56.16,37.24)
  IN4 w0.076: v2(49.54,12.57) 49.53,12.58 49.21,12.58 49.13,12.5 49.13,12.37 49.24,12.27 49.34,12.27 49.41,12.2 49.41,12.07 49.34,11.99 49.18,11.99 49.13,11.94 49.13,11.61 47.66,10.14 44.66,10.14 v5(44.46,9.94) 43.44,9.94 42.63,10.75 41.77,10.75 41.23,11.28 40.12,11.28 38.83,12.57 v2(38.36,12.57) ; v2(27.19,12.57) 27.18,12.58 26.86,12.58 26.78,12.5 26.78,12.37 26.88,12.27 26.98,12.27 27.06,12.2 27.06,12.07 26.98,11.99 26.83,11.99 26.78,11.94 26.78,11.61 25.31,10.14 22.31,10.14 v5(22.11,9.94) 21.09,9.94 20.28,10.75 19.42,10.75 18.88,11.28 17.76,11.28 16.47,12.57 v2(16.01,12.57)
  IN4 w0.165: v2(55.59,39.09) 56.03,39.09 56.16,38.96 v5(56.16,37.24)
M_A_A2: length 123
  TOP w0.089: v9(32.9,10.93) v7(31.2,10.93) 31.03,10.93 R425.2
  IN1 w0.076: v5(24.14,11.43) 22.9,11.43 22.74,11.28 22.74,10.98 22.87,10.85 24.55,10.85 24.66,10.96 24.66,11.6 24.83,11.76 25.26,11.76 25.99,11.03 30.9,11.03 30.92,11.05 30.92,11.16 31.02,11.26 31.2,11.26 31.27,11.18 31.27,11.1 31.35,11.03 31.5,11.03 31.58,11.1 31.58,11.18 31.66,11.26 31.81,11.26 31.88,11.18 31.88,11.1 31.96,11.03 32.21,11.03 32.27,11.08 32.27,11.18 32.35,11.26 32.62,11.26 32.67,11.21 32.67,11 32.75,10.93 v9(32.9,10.93) 42.63,10.93 43.11,11.41 46.47,11.41 v5(46.49,11.43)
  IN2 w0.089: 52.72,39.07 52.77,39.07 52.84,39.15 53,39.15 53.22,39.37 53.22,39.78 53.12,39.88 53.12,40.47 53.32,40.66 53.32,40.87 53.91,41.46 54.44,41.46 v5(54.98,41.99)
  IN2 w0.165: 52.72,39.07 51.02,37.37 39.44,37.37 29.56,27.49 29.56,26.37 29.42,26.23 28.3,26.23 28.1,26.03 28.1,20.64 28.23,20.52 29.44,20.52 29.56,20.39 29.56,20.12 29.44,19.99 28.23,19.99 28.1,19.87 28.1,19.51 28.23,19.38 29.8,19.38 29.93,19.26 29.93,18.93 29.8,18.8 28.69,18.8 28.56,18.67 28.56,18.37 28.69,18.24 30.67,18.24 31.24,17.67 31.24,16.78 31.33,16.69 31.33,12.81 31.84,12.3 31.84,11.99 32.19,11.64 32.19,10.22 32.47,9.94 32.8,9.94 33,10.14 33,10.82 v9(32.9,10.93)
  IN4 w0.076: v2(41.18,12.35) 40.78,12.35 40.68,12.25 40.68,11.97 40.75,11.89 41.01,11.89 41.16,12.04 43.09,12.04 43.55,11.59 46.34,11.59 v5(46.49,11.43) 46.82,11.43 47.48,12.09 47.48,12.45 48.3,13.26 50.91,13.26 51.65,12.53 52.69,12.53 v2(52.74,12.57) ; v2(30.39,12.57) 30.34,12.53 29.3,12.53 28.56,13.26 25.94,13.26 25.13,12.45 25.13,12.09 24.47,11.43 v5(24.14,11.43) 23.99,11.59 21.19,11.59 20.74,12.04 18.81,12.04 18.65,11.89 18.4,11.89 18.32,11.97 18.32,12.25 18.42,12.35 v2(18.83,12.35)
  IN4 w0.165: v5(54.98,41.99) 55.07,41.99 55.28,42.2 v2(55.38,42.2)
  BOTTOM w0.076: U18.P3 18.99,12.35 v2(18.83,12.35) ; U20.P3 41.34,12.35 v2(41.18,12.35)
M_A_A3: length 124.7
  TOP w0.089: v9(34.05,12.88) 33.66,12.5 v7(33.16,12.5) 32.68,12.5 30.61,14.58 30.61,14.77 30.19,15.18 R414.2
  IN1 w0.076: v5(24.37,13.8) 24.67,13.49 25.77,13.49 26.38,12.88 29.22,12.88 29.29,12.96 29.29,13.14 29.37,13.21 29.6,13.21 29.68,13.14 29.68,12.96 29.75,12.88 29.98,12.88 30.06,12.96 30.06,13.14 30.13,13.21 30.36,13.21 30.44,13.14 30.44,12.96 30.51,12.88 30.74,12.88 30.82,12.96 30.82,13.14 30.9,13.21 31.12,13.21 31.2,13.14 31.2,12.96 31.28,12.88 31.5,12.88 31.58,12.96 31.58,13.14 31.66,13.21 31.89,13.21 31.96,13.14 31.96,12.96 32.04,12.88 32.27,12.88 32.34,12.96 32.34,13.14 32.42,13.21 32.65,13.21 32.72,13.14 32.72,12.96 32.8,12.88 v9(34.05,12.88) 34.12,12.96 41.69,12.96 42.07,13.34 46.26,13.34 v5(46.72,13.8)
  IN2 w0.089: 54.95,38.56 54.95,38.94 54.82,39.07 54.82,39.45 54.49,39.78 54.49,40.24 54.84,40.58 54.84,40.89 55,41.05 55.79,41.05 55.89,41.15 55.89,41.51 55.51,41.89 55.51,42.5 55.69,42.68 v5(55.98,42.68)
  IN2 w0.165: 54.95,38.56 54.95,38.02 53.17,36.24 53.17,35.39 52.92,35.14 44.42,35.14 44.28,35.01 44.28,34.77 44.72,34.33 44.72,34.09 44.56,33.93 44.32,33.93 43.43,34.82 43.17,34.82 42.99,34.63 42.99,34.37 43.88,33.48 43.88,33.25 43.69,33.06 43.43,33.06 42.55,33.94 42.29,33.94 42.11,33.76 42.11,33.5 42.99,32.62 42.99,32.35 42.81,32.17 42.55,32.17 41.66,33.05 41.4,33.05 41.22,32.87 41.22,32.61 41.85,31.98 41.85,31.73 41.67,31.55 41.41,31.55 40.86,32.1 40.45,32.1 36.01,27.66 35.78,27.66 35.07,28.37 34.85,28.37 34.69,28.21 34.69,27.98 35.4,27.27 35.4,27.04 35.24,26.88 35.01,26.88 34.3,27.59 34.08,27.59 33.92,27.43 33.92,27.21 34.62,26.5 34.62,26.27 34.46,26.11 34.24,26.11 33.53,26.82 33.3,26.82 33.14,26.66 33.14,26.43 33.85,25.73 33.85,25.5 32.95,24.6 32.95,19.81 33.45,19.32 33.45,13.86 34.05,13.26 v9(34.05,12.88)
  IN4 w0.076: v2(42.36,13.37) 44.01,13.37 44.09,13.45 44.09,13.68 44.16,13.75 44.34,13.75 44.39,13.7 44.39,13.45 44.47,13.37 44.62,13.37 44.69,13.45 44.69,13.7 44.77,13.78 44.92,13.78 45,13.7 45,13.45 45.08,13.37 45.23,13.37 45.3,13.45 45.3,13.7 45.38,13.78 45.53,13.78 45.61,13.7 45.61,13.44 45.67,13.37 45.84,13.37 45.91,13.44 45.91,13.75 45.98,13.82 46.14,13.82 46.21,13.75 46.21,13.4 46.24,13.37 46.45,13.37 46.52,13.44 46.52,13.75 46.57,13.8 v5(46.72,13.8) 46.92,13.8 47.61,14.48 49.62,14.48 50.3,13.8 51.37,13.8 52.06,13.11 53.27,13.11 v2(53.54,13.37) ; v2(31.19,13.37) 30.92,13.11 29.71,13.11 28.94,13.87 27.87,13.87 27.26,14.48 25.26,14.48 24.57,13.8 v5(24.37,13.8) 24.22,13.8 24.17,13.75 24.17,13.44 24.1,13.37 23.89,13.37 23.86,13.4 23.86,13.75 23.78,13.82 23.63,13.82 23.56,13.75 23.56,13.44 23.49,13.37 23.32,13.37 23.26,13.44 23.26,13.7 23.18,13.78 23.03,13.78 22.95,13.7 22.95,13.45 22.88,13.37 22.72,13.37 22.65,13.45 22.65,13.7 22.57,13.78 22.42,13.78 22.34,13.7 22.34,13.45 22.27,13.37 22.11,13.37 22.04,13.45 22.04,13.7 21.99,13.75 21.81,13.75 21.73,13.68 21.73,13.45 21.66,13.37 v2(20.01,13.37)
  IN4 w0.165: v5(55.98,42.68) 56.15,42.85 v2(56.43,42.85)
M_A_A4: length 124.7
  TOP w0.089: R419.2 30.22,9.71 31.28,9.71 v7(31.35,9.63) 31.51,9.48 34.12,9.48 v9(34.38,9.73)
  IN1 w0.076: v5(21.52,10.42) 21.52,10.57 21.68,10.72 21.88,10.72 22.64,9.96 31.1,9.96 31.33,9.73 32.14,9.73 32.22,9.66 32.22,9.63 32.3,9.55 32.45,9.55 32.52,9.63 32.52,9.66 32.6,9.73 32.75,9.73 32.83,9.66 32.83,9.63 32.91,9.55 33.06,9.55 33.13,9.63 33.13,9.66 33.21,9.73 33.36,9.73 33.44,9.66 33.44,9.63 33.51,9.55 33.67,9.55 33.74,9.63 33.74,9.66 33.82,9.73 v9(34.38,9.73) 34.73,9.73 34.81,9.81 34.81,9.86 34.88,9.94 35.04,9.94 35.09,9.89 35.09,9.66 35.16,9.58 35.32,9.58 35.39,9.66 35.39,9.89 35.44,9.94 35.65,9.94 35.7,9.89 35.7,9.66 35.77,9.58 35.93,9.58 36,9.66 36,9.86 36.08,9.94 36.26,9.94 36.33,9.86 36.33,9.78 36.41,9.71 36.56,9.71 36.64,9.78 36.64,9.86 36.71,9.94 36.87,9.94 36.94,9.86 36.94,9.78 37.02,9.71 37.17,9.71 37.25,9.78 37.25,9.86 37.32,9.94 37.47,9.94 37.55,9.86 37.55,9.78 37.63,9.71 37.78,9.71 37.86,9.78 37.86,9.86 37.93,9.94 38.08,9.94 38.16,9.86 38.16,9.78 38.24,9.71 38.39,9.71 38.47,9.78 38.47,9.86 38.54,9.94 38.69,9.94 38.77,9.86 38.77,9.78 38.85,9.71 39,9.71 39.08,9.78 39.08,9.86 39.15,9.94 39.3,9.94 39.38,9.86 39.38,9.78 39.46,9.71 39.61,9.71 39.68,9.78 39.68,9.86 39.76,9.94 39.91,9.94 39.99,9.86 39.99,9.78 40.07,9.71 40.22,9.71 40.29,9.78 40.29,9.86 40.37,9.94 40.52,9.94 40.6,9.86 40.6,9.78 40.68,9.71 40.83,9.71 40.9,9.78 40.9,9.86 40.98,9.94 41.13,9.94 41.21,9.86 41.21,9.78 41.28,9.71 41.44,9.71 41.51,9.78 41.51,9.86 41.59,9.94 41.74,9.94 41.82,9.86 41.82,9.78 41.89,9.71 42.05,9.71 42.1,9.76 42.1,9.86 42.17,9.94 42.35,9.94 42.43,9.86 42.43,9.76 42.45,9.73 42.73,9.73 43.42,10.42 v5(43.88,10.42)
  IN2 w0.165: v5(54.44,40.72) 54.37,40.8 54.14,40.8 54.06,40.72 54.06,40.03 53.96,39.93 53.96,39.22 53.85,39.11 53.85,38.5 51.59,36.24 39.88,36.24 36.66,33.03 36.66,32.85 37.07,32.43 37.07,32.18 36.81,31.92 36.59,31.92 36.18,32.32 35.96,32.32 35.8,32.16 35.8,31.94 36.2,31.53 36.2,31.31 36.04,31.15 35.81,31.15 35.41,31.55 35.18,31.55 35.02,31.39 35.02,31.16 35.43,30.76 35.43,30.53 35.27,30.37 35.04,30.37 34.64,30.78 34.41,30.78 34.25,30.62 34.25,30.39 34.66,29.99 34.66,29.76 34.5,29.6 34.27,29.6 33.86,30.01 33.64,30.01 33.48,29.85 33.48,29.62 33.88,29.21 33.88,28.99 33.72,28.83 33.5,28.83 33.09,29.23 32.87,29.23 32.71,29.07 32.71,28.85 33.11,28.44 33.11,28.22 32.95,28.06 32.72,28.06 32.32,28.46 32.09,28.46 31.93,28.3 31.93,28.07 32.36,27.64 32.36,27.47 32.12,27.23 31.95,27.23 31.51,27.67 31.3,27.67 30.96,27.33 30.96,26.86 31.12,26.7 31.61,26.7 31.77,26.54 31.77,26.32 31.61,26.16 31.12,26.16 30.96,26 30.96,25.77 31.12,25.61 31.61,25.61 31.77,25.45 31.77,22.95 31.76,22.94 31.76,19.14 32.22,18.68 32.22,18.04 32.04,17.86 32.04,17.43 32.39,17.07 32.39,13.36 33.03,12.73 33.03,12.19 33.97,11.25 33.97,9.83 34.07,9.73 v9(34.38,9.73)
  IN4 w0.076: v2(37.56,12.57) 37.56,12.79 37.63,12.86 39.02,12.86 40.29,11.59 41.34,11.59 41.89,11.03 42.76,11.03 43.37,10.42 v5(43.88,10.42) 44,10.29 44.38,10.29 44.51,10.42 46.65,10.42 46.73,10.49 47.01,10.49 47.08,10.42 47.53,10.42 47.84,10.72 47.84,10.8 47.99,10.95 48.07,10.95 48.17,11.06 48.17,11.16 48.4,11.38 48.5,11.38 48.6,11.49 48.6,11.64 48.42,11.82 48.42,11.89 48.47,11.94 48.78,11.94 48.85,12.02 48.85,12.17 48.78,12.25 48.47,12.25 48.44,12.29 48.44,12.44 48.57,12.57 v2(48.74,12.57) ; v2(15.21,12.57) 15.5,12.86 16.67,12.86 17.94,11.59 18.98,11.59 19.54,11.03 20.41,11.03 21.02,10.42 v5(21.52,10.42) 24.22,10.42 24.3,10.49 24.58,10.49 24.66,10.42 25.18,10.42 25.58,10.82 25.58,10.92 25.71,11.05 25.82,11.05 25.9,11.14 25.9,11.24 26.12,11.46 26.22,11.46 26.27,11.51 26.27,11.61 26.07,11.82 26.07,11.92 26.13,11.98 26.44,11.98 26.51,12.05 26.51,12.2 26.43,12.29 26.13,12.29 26.08,12.34 26.08,12.46 26.19,12.57 v2(26.39,12.57)
  IN4 w0.165: v5(54.44,40.72) 54.76,41.04 v2(54.89,41.04)
M_A_A5: length 124
  TOP w0.089: R427.2 36.03,10.88 v7(35.98,10.93) 35.62,11.28 v9(35.49,11.28)
  IN1 w0.076: v5(46.92,12.07) 46.64,11.79 46.35,11.79 46.28,11.87 46.28,12.63 46.2,12.7 46.05,12.7 45.97,12.63 45.97,11.87 45.9,11.79 45.74,11.79 45.67,11.87 45.67,12.63 45.59,12.7 45.44,12.7 45.36,12.63 45.36,11.87 45.29,11.79 45.13,11.79 45.06,11.87 45.06,12.27 44.98,12.35 44.83,12.35 44.75,12.27 44.75,11.87 44.68,11.79 43.04,11.79 42.58,11.33 35.54,11.33 v9(35.49,11.28) 35.49,11.51 35.32,11.69 35.06,11.69 35.01,11.64 35.01,11.26 34.93,11.18 34.78,11.18 34.71,11.26 34.71,11.66 34.66,11.71 34.48,11.71 34.41,11.64 34.41,11.28 34.33,11.21 34.18,11.21 34.1,11.28 34.1,11.64 34.03,11.71 33.87,11.71 33.8,11.64 33.8,11.28 33.72,11.21 33.57,11.21 33.49,11.28 33.49,11.64 33.42,11.71 33.26,11.71 33.19,11.64 33.19,11.28 33.11,11.21 32.96,11.21 32.9,11.26 32.9,11.46 32.83,11.54 32.73,11.54 32.65,11.61 32.65,11.66 32.6,11.71 32.45,11.71 32.39,11.66 32.39,11.64 32.29,11.54 32.17,11.54 32.09,11.61 32.09,11.64 32.01,11.71 31.86,11.71 31.79,11.64 31.79,11.61 31.71,11.54 31.56,11.54 31.48,11.61 31.48,11.64 31.4,11.71 31.25,11.71 31.18,11.64 31.18,11.61 31.1,11.54 30.92,11.54 30.67,11.28 29.87,11.28 29.8,11.35 29.63,11.35 29.56,11.28 29.26,11.28 29.19,11.35 29.02,11.35 28.95,11.28 28.65,11.28 28.58,11.35 28.41,11.35 28.34,11.28 28.04,11.28 27.98,11.35 27.8,11.35 27.73,11.28 27.43,11.28 27.37,11.35 27.19,11.35 27.12,11.28 26.82,11.28 26.76,11.35 26.58,11.35 26.51,11.28 26.17,11.28 25.26,12.2 24.7,12.2 v5(24.57,12.07)
  IN2 w0.089: 56.42,41.08 56.42,41.58 v5(55.98,42.02)
  IN2 w0.165: v9(35.49,11.28) 35.32,11.46 35.32,11.89 35.06,12.15 35.06,12.7 35.24,12.88 35.54,12.88 35.77,13.11 35.77,13.54 34.72,14.6 34.72,17.03 35.14,17.45 35.14,17.84 36.28,18.98 36.28,20.84 45.44,30 50.84,30 50.96,29.87 50.96,28.08 51.09,27.96 51.44,27.96 51.57,28.08 51.57,29.87 51.7,30 52.05,30 52.18,29.87 52.18,28.88 52.31,28.75 52.63,28.75 52.75,28.88 52.75,31.35 52.88,31.48 53.22,31.48 53.35,31.35 53.35,30.04 53.48,29.91 53.78,29.91 53.91,30.04 53.91,31.86 54.04,31.99 54.37,31.99 54.49,31.86 54.49,31.2 54.62,31.08 54.95,31.08 55.08,31.2 55.08,33.01 55.84,33.77 57.12,33.77 57.33,33.98 57.33,37.71 56.42,38.61 56.42,41.08
  IN4 w0.076: v2(41.95,12.35) 43.27,12.35 43.41,12.21 43.41,12.01 43.57,11.84 44.38,11.84 44.46,11.92 44.46,12.04 44.56,12.15 44.69,12.15 44.76,12.07 44.76,11.92 44.84,11.84 44.99,11.84 45.07,11.92 45.07,12.07 45.14,12.15 45.3,12.15 45.37,12.07 45.37,11.92 45.45,11.84 45.6,11.84 45.68,11.92 45.68,12.07 45.75,12.15 45.91,12.15 45.98,12.07 45.98,11.87 46.06,11.79 46.21,11.79 46.26,11.84 46.26,11.94 46.42,12.09 46.9,12.09 v5(46.92,12.07) 46.92,12.27 48.13,13.48 51.18,13.48 51.81,12.84 53.44,12.84 53.54,12.74 v2(53.54,12.57) ; v2(19.59,12.35) 21.04,12.35 21.14,12.25 21.14,11.92 21.22,11.84 22.03,11.84 22.11,11.92 22.11,12.04 22.21,12.15 22.33,12.15 22.41,12.07 22.41,11.92 22.49,11.84 22.64,11.84 22.71,11.92 22.71,12.07 22.79,12.15 22.94,12.15 23.02,12.07 23.02,11.92 23.1,11.84 23.25,11.84 23.32,11.92 23.32,12.07 23.4,12.15 23.55,12.15 23.63,12.07 23.63,11.87 23.71,11.79 23.86,11.79 23.91,11.84 23.91,12.02 23.99,12.09 24.55,12.09 v5(24.57,12.07) 24.77,12.07 24.9,12.2 24.9,12.6 25.78,13.48 28.83,13.48 29.46,12.84 31.11,12.84 31.19,12.77 v2(31.19,12.57)
  IN4 w0.165: v2(56.43,42.2) 56.15,42.2 v5(55.98,42.02)
  BOTTOM w0.076: U20.P2 42.36,12.29 42.22,12.15 42.05,12.15 41.95,12.25 v2(41.95,12.35) ; U18.P2 20.01,12.29 19.87,12.15 19.69,12.15 19.59,12.25 v2(19.59,12.35)
M_A_A6: length 131.4
  TOP w0.089: R416.2 39.97,7.58 39.66,7.27 36,7.27 35.9,7.37 v7(34.93,7.37) 34.48,7.37 v9(34.12,7.73)
  IN1 w0.076: v5(22.57,7.7) 22.59,7.73 v9(34.12,7.73) 44.21,7.73 44.74,8.26 44.87,8.26 44.92,8.21 v5(44.92,7.7)
  IN2 w0.089: 53.51,39.07 53.65,39.21 v5(53.65,40.21)
  IN2 w0.165: 53.51,39.07 53.51,38.72 51.4,36.61 39.72,36.61 30.3,27.19 30.3,25.4 30.45,25.24 31.27,25.24 31.4,25.12 31.4,24.75 31.24,24.59 30.43,24.59 30.3,24.46 30.3,24.17 30.43,24.05 31.24,24.05 31.4,23.89 31.4,23.66 31.24,23.5 30.43,23.5 30.3,23.37 30.3,23.08 30.43,22.95 31.24,22.95 31.4,22.79 31.4,22.57 31.24,22.41 30.43,22.41 30.3,22.28 30.3,21.99 30.43,21.86 31.24,21.86 31.4,21.7 31.4,21.47 31.24,21.31 30.43,21.31 30.3,21.19 30.3,20.9 30.43,20.77 31.24,20.77 31.4,20.61 31.4,20.38 31.24,20.22 30.95,20.22 30.82,20.1 30.82,19.8 30.95,19.68 31.24,19.68 31.4,19.52 31.4,18.9 31.77,18.52 31.77,17.21 32.04,16.95 32.04,13.14 32.66,12.51 32.66,12.09 33.66,11.09 33.66,10.06 33.46,9.86 33.46,7.14 33.61,6.99 33.9,6.99 34.02,7.12 34.02,7.62 v9(34.12,7.73)
  IN4 w0.076: v2(15.21,11.77) 15.21,10.94 16.06,10.09 18.37,10.09 20.76,7.7 21.79,7.7 21.86,7.62 21.86,7.4 21.94,7.32 22.09,7.32 22.17,7.4 22.17,7.62 22.25,7.7 v5(22.57,7.7) 22.59,7.7 22.69,7.8 25.84,7.8 27.92,9.89 27.92,10.77 v2(28.08,10.93) ; v2(50.43,10.93) 50.28,10.77 50.28,9.89 48.07,7.68 44.94,7.68 v5(44.92,7.7) 44.6,7.7 44.52,7.62 44.52,7.4 44.45,7.32 44.29,7.32 44.22,7.4 44.22,7.62 44.14,7.7 43.11,7.7 40.73,10.09 38.41,10.09 37.56,10.94 v2(37.56,11.77)
  IN4 w0.165: v2(54.01,40.39) 53.83,40.21 v5(53.65,40.21)
  BOTTOM w0.076: U21.R8 49.14,12.17 49.72,12.17 50.43,11.46 v2(50.43,10.93) ; v2(28.08,10.93) 28.08,11.46 27.37,12.17 26.79,12.17 U19.R8
M_A_A7: length 121.1
  TOP w0.089: v9(34.58,10.49) 34.6,10.49 v7(35.2,9.9) 35.24,9.86 R418.2
  IN1 w0.076: v5(25.11,11.41) 26,10.52 26.28,10.52 26.35,10.59 26.35,10.67 26.43,10.75 26.58,10.75 26.66,10.67 26.66,10.59 26.73,10.52 26.89,10.52 26.96,10.59 26.96,10.67 27.04,10.75 27.19,10.75 27.27,10.67 27.27,10.59 27.34,10.52 27.5,10.52 27.57,10.59 27.57,10.67 27.65,10.75 27.8,10.75 27.88,10.67 27.88,10.59 27.95,10.52 28.1,10.52 28.18,10.59 28.18,10.67 28.26,10.75 28.41,10.75 28.49,10.67 28.49,10.59 28.56,10.52 28.71,10.52 28.79,10.59 28.79,10.67 28.87,10.75 29.02,10.75 29.1,10.67 29.1,10.59 29.17,10.52 29.32,10.52 29.4,10.59 29.4,10.67 29.48,10.75 29.63,10.75 29.71,10.67 29.71,10.59 29.78,10.52 29.93,10.52 30.01,10.59 30.01,10.67 30.09,10.75 30.24,10.75 30.31,10.67 30.31,10.59 30.39,10.52 30.54,10.52 30.62,10.59 30.62,10.67 30.7,10.75 30.85,10.75 30.92,10.67 30.92,10.59 31,10.52 31.15,10.52 31.23,10.59 31.23,10.67 31.31,10.75 31.46,10.75 31.53,10.67 31.53,10.59 31.58,10.54 31.84,10.54 31.91,10.62 31.91,10.7 31.99,10.77 32.14,10.77 32.22,10.7 32.22,10.62 32.3,10.54 34.53,10.54 v9(34.58,10.49) 42.63,10.49 43.22,11.08 47.13,11.08 v5(47.46,11.41)
  IN2 w0.165: v5(54.44,39.3) 54.13,38.99 54.13,38.25 51.76,35.88 43.19,35.88 42.44,35.13 42.25,35.13 41.67,35.71 41.43,35.71 41.26,35.54 41.26,35.31 41.87,34.7 41.87,34.56 41.64,34.33 41.41,34.33 40.06,35.68 39.83,35.68 39.67,35.52 39.67,35.29 41.02,33.94 41.02,33.71 40.86,33.55 40.64,33.55 39.28,34.91 39.06,34.91 38.9,34.75 38.9,34.52 40.25,33.17 40.25,32.94 40.09,32.78 39.86,32.78 38.51,34.13 38.29,34.13 38.13,33.97 38.13,33.75 39.48,32.39 39.48,32.17 39.22,31.91 39.03,31.91 37.67,33.26 37.41,33.26 37.23,33.07 37.23,32.81 37.63,32.41 37.63,32.21 32.14,26.72 32.14,19.4 32.67,18.87 32.67,18.17 32.92,17.92 32.92,17.37 32.75,17.2 32.75,13.52 33.42,12.85 33.42,12.3 34.27,11.44 34.27,10.8 v9(34.58,10.49)
  IN4 w0.076: v2(42.36,11.77) 42.36,11.65 42.43,11.59 42.61,11.59 42.71,11.69 42.71,11.82 42.76,11.87 42.94,11.87 42.99,11.82 42.99,11.71 43.62,11.09 43.69,11.09 43.77,11.16 43.77,11.23 43.84,11.31 44,11.31 44.07,11.23 44.07,11.13 44.15,11.05 44.3,11.05 44.38,11.13 44.38,11.23 44.45,11.31 44.61,11.31 44.68,11.23 44.68,11.13 44.76,11.05 44.91,11.05 44.99,11.13 44.99,11.23 45.06,11.31 45.22,11.31 45.29,11.23 45.29,11.13 45.37,11.05 45.51,11.05 45.58,11.12 45.58,11.26 45.63,11.31 45.83,11.31 45.88,11.26 45.88,11.14 45.93,11.09 47.13,11.09 v5(47.46,11.41) 47.84,11.79 47.84,12.45 48.45,13.06 50.68,13.06 51.55,12.2 53.12,12.2 v2(53.54,11.77) ; v2(31.19,11.77) 30.76,12.2 29.19,12.2 28.33,13.06 26.1,13.06 25.49,12.45 25.49,11.79 v5(25.11,11.41) 24.75,11.05 24.03,11.05 23.88,11.21 23.73,11.21 23.58,11.05 23.48,11.05 23.4,11.13 23.4,11.23 23.33,11.31 23.17,11.31 23.12,11.26 23.12,11.1 23.08,11.05 22.9,11.05 22.84,11.11 22.84,11.23 22.76,11.31 22.61,11.31 22.53,11.23 22.53,11.1 22.48,11.05 22.29,11.05 22.23,11.11 22.23,11.23 22.15,11.31 22,11.31 21.92,11.23 21.92,11.1 21.87,11.05 21.68,11.05 21.62,11.11 21.62,11.23 21.54,11.31 21.39,11.31 21.31,11.23 21.31,11.14 21.26,11.09 21.16,11.09 20.66,11.59 20.66,11.79 20.58,11.87 20.41,11.87 20.36,11.82 20.36,11.64 20.3,11.59 20.08,11.59 20.01,11.65 v2(20.01,11.77)
  IN4 w0.165: v2(54.84,39.74) 54.84,39.7 v5(54.44,39.3)
M_A_A8: length 121.9
  TOP w0.089: v9(34.38,8.64) 34.17,8.44 v7(33.46,8.44) 33.08,8.82 30.09,8.82 R420.2
  IN1 w0.076: v5(43.93,9.02) 43.52,9.02 43.09,8.59 42.25,8.59 42.17,8.67 42.17,8.74 42.1,8.82 41.95,8.82 41.87,8.74 41.87,8.67 41.79,8.59 41.59,8.59 41.51,8.67 41.51,8.77 41.44,8.84 41.26,8.84 41.18,8.77 41.18,8.64 41.13,8.59 40.94,8.59 40.87,8.67 40.87,8.77 40.79,8.84 40.64,8.84 40.56,8.77 40.56,8.67 40.49,8.59 40.33,8.59 40.26,8.67 40.26,8.77 40.18,8.84 40.03,8.84 39.95,8.77 39.95,8.67 39.88,8.59 39.72,8.59 39.65,8.67 39.65,8.77 39.57,8.84 39.42,8.84 39.34,8.77 39.34,8.67 39.27,8.59 39.11,8.59 39.04,8.67 39.04,8.77 38.96,8.84 38.81,8.84 38.73,8.77 38.73,8.67 38.66,8.59 38.51,8.59 38.43,8.67 38.43,8.77 38.35,8.84 38.2,8.84 38.12,8.77 38.12,8.67 38.05,8.59 37.9,8.59 37.82,8.67 37.82,8.77 37.74,8.84 37.59,8.84 37.51,8.77 37.51,8.67 37.44,8.59 37.29,8.59 37.21,8.67 37.21,8.77 37.13,8.84 36.98,8.84 36.9,8.77 36.9,8.67 36.83,8.59 34.43,8.59 v9(34.38,8.64) 34.34,8.6 29.41,8.6 29.17,8.84 24.17,8.84 23.63,9.38 21.93,9.38 v5(21.57,9.02)
  IN2 w0.165: v5(54.54,38.79) 54.54,38.08 51.97,35.51 43.34,35.51 39.25,31.41 39,31.41 38.29,32.12 38.06,32.12 37.9,31.96 37.9,31.74 38.62,31.02 38.62,30.79 38.46,30.63 38.24,30.63 37.51,31.35 37.29,31.35 37.13,31.19 37.13,30.97 37.85,30.24 37.85,30.02 37.69,29.86 37.46,29.86 36.74,30.58 36.52,30.58 36.36,30.42 36.36,30.19 37.08,29.47 37.08,29.25 36.92,29.09 36.69,29.09 35.97,29.81 35.74,29.81 35.58,29.65 35.58,29.42 36.3,28.7 36.3,28.47 36.04,28.21 35.77,28.21 35.08,28.91 34.85,28.91 32.55,26.61 32.55,26.42 33.28,25.69 33.28,25.45 32.55,24.72 32.55,19.65 33.18,19.01 33.18,17.09 33.11,17.01 33.11,13.69 33.73,13.06 33.73,12.49 34.62,11.6 34.62,11.01 34.92,10.7 34.92,10.38 34.72,10.18 34.72,9.62 34.5,9.4 34.05,9.4 33.84,9.2 33.84,8.49 34.6,7.73 34.78,7.73 35.05,7.99 35.05,8.17 34.58,8.64 v9(34.38,8.64)
  IN4 w0.076: v2(38.19,11.37) 38.27,11.28 39.68,11.28 39.99,10.98 41.08,10.98 43.04,9.02 v5(43.93,9.02) 45.17,9.02 45.45,9.3 46.62,9.3 46.7,9.22 46.7,9.1 46.77,9.02 47.15,9.02 47.36,8.82 47.56,8.82 47.79,9.04 47.79,9.15 47.7,9.24 47.7,9.34 47.81,9.45 47.92,9.45 48,9.37 48.11,9.37 48.31,9.57 48.31,9.67 48.21,9.77 48.21,9.88 48.31,9.99 48.42,9.99 48.52,9.89 48.63,9.89 48.83,10.09 v2(48.83,10.52) ; v2(15.83,11.37) 15.92,11.28 17.33,11.28 17.64,10.98 18.73,10.98 20.69,9.02 v5(21.57,9.02) 22.49,9.02 23.02,9.55 23.28,9.55 23.73,9.1 23.89,9.1 23.96,9.17 23.96,9.48 24.06,9.58 24.24,9.58 24.34,9.48 24.34,9.1 24.42,9.02 25.41,9.02 26.48,10.09 v2(26.48,10.52)
  IN4 w0.165: v5(54.54,38.79) v2(54.84,39.09)
  BOTTOM w0.076: v2(15.83,11.37) 15.61,11.37 U18.T8 ; v2(26.48,10.52) 26.48,10.88 U19.T8 ; v2(38.19,11.37) 37.96,11.37 U20.T8 ; U21.T8 48.83,10.88 v2(48.83,10.52)
M_A_A9: length 122.4
  TOP w0.089: R426.2 30.73,10.22 v7(32.62,10.22) v9(33.33,10.22)
  IN1 w0.076: v5(47.38,10.77) 45.2,10.77 45.17,10.8 43.34,10.8 42.76,10.22 v9(33.33,10.22) 33.31,10.24 33,10.24 32.95,10.19 32.95,10.06 32.9,10.01 32.73,10.01 32.67,10.06 32.67,10.19 32.63,10.24 32.46,10.24 32.38,10.16 32.38,10.09 32.31,10.01 32.16,10.01 32.08,10.09 32.08,10.16 32,10.24 31.85,10.24 31.77,10.16 31.77,10.09 31.7,10.01 31.55,10.01 31.47,10.09 31.47,10.16 31.39,10.24 22.92,10.24 22.8,10.36 22.8,10.47 22.9,10.57 24.83,10.57 v5(25.03,10.77)
  IN2 w0.089: v5(53.65,40.72) 53.3,40.37 53.3,40.06 53.45,39.91 53.45,39.33 53.25,39.12 53.25,39.07
  IN2 w0.165: v9(33.33,10.22) 33.33,10.94 32.28,11.99 32.28,12.4 31.68,12.99 31.68,16.79 31.51,16.97 31.51,18.04 30.36,19.18 30.36,20.1 29.93,20.53 29.93,20.76 29.8,20.88 28.6,20.88 28.47,21.01 28.47,21.32 28.6,21.44 29.8,21.44 29.93,21.57 29.93,21.85 29.77,22.01 28.63,22.01 28.47,22.17 28.47,22.4 28.63,22.56 29.77,22.56 29.93,22.72 29.93,22.95 29.77,23.11 28.63,23.11 28.47,23.27 28.47,23.49 28.63,23.65 29.77,23.65 29.93,23.81 29.93,24.04 29.77,24.2 28.63,24.2 28.47,24.36 28.47,24.59 28.63,24.75 29.77,24.75 29.93,24.91 29.93,25.18 29.8,25.3 28.6,25.3 28.47,25.43 28.47,25.73 28.6,25.86 29.8,25.86 29.93,25.99 29.93,27.34 39.57,36.98 51.16,36.98 53.25,39.07
  IN4 w0.076: v2(19.21,11.77) 19.27,11.71 19.36,11.71 19.47,11.82 19.59,11.82 19.69,11.71 19.69,11.61 19.57,11.49 19.57,11.41 19.67,11.31 20.53,11.31 21.14,10.7 21.3,10.7 21.37,10.77 21.86,10.77 21.94,10.7 22.17,10.7 22.24,10.77 22.47,10.77 22.55,10.7 22.78,10.7 22.85,10.77 23.08,10.77 23.16,10.7 23.39,10.7 23.46,10.77 23.69,10.77 23.77,10.7 24,10.7 24.07,10.77 v5(25.03,10.77) 25.79,11.54 25.79,12.43 26.2,12.84 27.87,12.84 28.93,11.77 v2(30.39,11.77) ; v2(52.74,11.77) 51.29,11.77 50.22,12.84 48.56,12.84 48.14,12.43 48.14,11.54 v5(47.38,10.77) 46.43,10.77 46.35,10.7 46.12,10.7 46.04,10.77 45.82,10.77 45.74,10.7 45.51,10.7 45.43,10.77 45.21,10.77 45.13,10.7 44.9,10.7 44.82,10.77 44.6,10.77 44.52,10.7 44.29,10.7 44.22,10.77 43.42,10.77 42.89,11.31 42.12,11.31 42.02,11.41 42.02,11.74 41.95,11.82 41.61,11.82 v2(41.56,11.77)
  IN4 w0.165: v5(53.65,40.72) 53.97,41.03 v2(53.97,41.04)
M_A_A10: length 118.7
  TOP w0.089: R411.2 36.84,15.38 v9(36.84,15.02)
  IN1 w0.076: v5(22.23,15.07) 22.69,15.52 25,15.52 25.51,15.02 v9(36.84,15.02) 37.11,15.02 37.18,15.09 37.18,15.14 37.26,15.22 37.41,15.22 37.49,15.14 37.49,14.95 37.55,14.89 37.73,14.89 37.79,14.95 37.79,15.14 37.87,15.22 38.63,15.22 38.71,15.14 38.71,14.71 38.78,14.63 38.94,14.63 39.01,14.71 39.01,15.14 39.09,15.22 39.24,15.22 39.32,15.14 39.32,14.71 39.39,14.63 39.55,14.63 39.62,14.71 39.62,15.14 39.7,15.22 39.85,15.22 39.93,15.14 39.93,14.71 40,14.63 40.15,14.63 40.23,14.71 40.23,15.14 40.31,15.22 41.19,15.22 41.26,15.14 41.26,14.86 41.34,14.79 41.57,14.79 41.64,14.86 41.64,15.14 41.72,15.22 41.95,15.22 42.03,15.14 42.03,14.84 42.1,14.76 42.33,14.76 42.41,14.84 42.41,15.14 42.48,15.22 42.71,15.22 42.79,15.14 42.79,14.84 42.86,14.76 43.09,14.76 43.17,14.84 43.17,15.14 43.24,15.22 43.47,15.22 43.55,15.14 43.55,14.84 43.63,14.76 43.8,14.76 43.85,14.81 43.85,15.14 43.93,15.22 44.08,15.22 44.16,15.14 44.16,14.91 44.28,14.79 44.49,14.79 44.59,14.89 v5(44.59,15.07)
  IN2 w0.165: v9(36.84,15.02) 37.35,15.02 37.83,14.53 37.83,12.86 37.96,12.73 38.36,12.73 38.49,12.86 38.49,14.41 38.62,14.53 39,14.53 39.13,14.41 39.13,12.88 39.25,12.76 39.71,12.76 39.84,12.88 39.84,14.63 40.27,15.07 41.18,15.07 42.22,14.03 45.07,14.03 45.88,13.21 47.1,13.21 47.23,13.34 47.23,13.92 47.36,14.05 47.69,14.05 47.81,13.92 47.81,13.34 47.94,13.21 48.22,13.21 48.35,13.34 48.35,19.64 49.44,20.73 51.62,20.73 61.5,30.61 61.5,42.04 60.21,43.34 57.57,43.34 56.91,42.68 v5(56.91,42.52)
  IN4 w0.076: v2(27.57,15.4) 26.35,15.4 26.25,15.5 23.33,15.5 23.15,15.32 22.31,15.32 22.23,15.24 v5(22.23,15.07) 21.7,15.07 21.09,14.46 19.16,14.46 18.68,14.94 16.06,14.94 16.03,14.97 v2(16.01,14.97) ; v2(49.92,15.4) 48.7,15.4 48.6,15.5 45.68,15.5 45.5,15.32 44.66,15.32 44.59,15.24 v5(44.59,15.07) 44.05,15.07 43.44,14.46 41.51,14.46 41.03,14.94 38.41,14.94 38.38,14.97 v2(38.36,14.97)
  IN4 w0.165: v5(56.91,42.52) 57.23,42.85 v2(57.29,42.85)
  BOTTOM w0.076: U19.L7 v2(27.57,15.4)
  BOTTOM w0.127: U21.L7 v2(49.92,15.4)
M_A_A11: length 123.3
  TOP w0.089: v9(33,8.03) 32.5,7.52 v6(30.82,7.52) 30.36,7.52 30.03,7.19 R422.2
  IN1 w0.076: v5(21.88,8.26) 21.88,8.13 22.03,7.98 22.26,7.98 22.54,8.26 22.67,8.26 22.9,8.03 v9(33,8.03) 43.6,8.03 43.95,8.39 44.1,8.39 v5(44.23,8.26)
  IN2 w0.165: v5(52.88,39.5) 52.85,39.53 52.85,39.97 52.72,40.11 52.36,40.11 52.21,39.96 52.21,39.25 50.71,37.75 47.33,37.75 47.2,37.88 47.2,38.55 47.08,38.68 46.75,38.68 46.62,38.55 46.62,37.88 46.49,37.75 46.11,37.75 45.98,37.88 45.98,38.56 45.86,38.69 45.49,38.69 45.36,38.56 45.36,37.88 45.24,37.75 39.3,37.75 34.74,33.19 34.5,33.19 34.17,33.52 33.94,33.52 33.7,33.29 33.7,33.05 34.03,32.72 34.03,32.49 33.77,32.22 33.54,32.22 33.21,32.56 32.97,32.56 32.74,32.32 32.74,32.09 33.07,31.76 33.07,31.52 32.84,31.29 32.6,31.29 32.27,31.62 32.04,31.62 31.8,31.39 31.8,31.16 32.14,30.82 32.14,30.59 31.9,30.36 31.67,30.36 31.34,30.69 31.1,30.69 30.87,30.45 30.87,29.32 27.73,26.19 27.73,18.67 28.55,17.86 30.48,17.86 30.97,17.37 30.97,12.68 31.37,12.28 31.37,10.22 32.17,9.43 32.98,9.43 33.08,9.33 33.08,8.11 v9(33,8.03)
  IN4 w0.076: v2(50,10.93) 49.82,10.75 49.72,10.75 49.51,10.55 49.51,9.58 47.91,7.98 46.42,7.98 46.26,8.13 44.36,8.13 v5(44.23,8.26) 42.96,8.26 40.85,10.37 38.54,10.37 37.88,11.03 37.88,11.64 38.02,11.77 v2(38.36,11.77) ; v2(27.65,10.93) 27.57,10.93 27.26,10.62 27.26,9.71 25.69,8.13 22.01,8.13 v5(21.88,8.26) 21.75,8.13 20.74,8.13 18.5,10.37 16.19,10.37 15.57,10.99 15.57,11.68 15.66,11.77 v2(16.01,11.77)
  IN4 w0.165: v5(52.88,39.5) 53.11,39.74 v2(53.27,39.74)
  BOTTOM w0.076: U21.R7 50,11.31 v2(50,10.93) ; v2(27.65,10.93) 27.65,11.31 U19.R7
M_A_A12: length 119.3
  TOP w0.089: R423.2 31.25,13.37 v7(31.25,13.01) 31.25,12.63 v9(30.9,12.27)
  IN1 w0.076: v5(44.97,12.73) 44.84,12.6 42.35,12.6 42.02,12.27 v9(30.9,12.27) 30.41,12.27 30.36,12.22 30.36,11.99 30.28,11.91 30.09,11.91 30.01,11.99 30.01,12.25 29.94,12.32 29.79,12.32 29.71,12.25 29.71,11.99 29.63,11.91 29.48,11.91 29.41,11.99 29.41,12.25 29.33,12.32 29.18,12.32 29.1,12.25 29.1,11.99 29.02,11.91 28.87,11.91 28.8,11.99 28.8,12.25 28.72,12.32 28.57,12.32 28.49,12.25 28.49,11.99 28.4,11.89 28.28,11.89 28.19,11.99 28.19,12.25 28.11,12.32 27.96,12.32 27.88,12.25 27.88,11.95 27.82,11.89 27.67,11.89 27.58,11.99 27.58,12.25 27.5,12.32 27.35,12.32 27.27,12.25 27.27,11.98 27.19,11.89 27.04,11.89 26.97,11.96 26.97,12.25 26.89,12.32 26.74,12.32 26.66,12.25 26.66,12.01 26.59,11.93 26.41,11.93 25.41,12.93 22.82,12.93 v5(22.62,12.73)
  IN2 w0.165: v5(52.84,41.08) 52.71,41.08 51.83,40.19 51.83,39.4 50.56,38.13 48.14,38.13 47.22,39.06 45.16,39.06 44.99,38.89 44.99,38.3 44.83,38.13 39.16,38.13 38.7,37.67 38.49,37.67 38.12,38.04 37.94,38.04 37.66,37.76 37.66,37.58 38.02,37.22 38.02,36.99 37.78,36.76 37.55,36.76 37.22,37.09 36.98,37.09 36.75,36.86 36.75,36.62 37.08,36.29 37.08,36.06 36.85,35.82 36.62,35.82 36.28,36.16 36.05,36.16 35.82,35.92 35.82,35.69 36.15,35.36 36.15,35.12 35.92,34.89 35.68,34.89 35.35,35.22 35.12,35.22 34.88,34.99 34.88,34.75 35.21,34.42 35.21,34.19 34.98,33.96 34.75,33.96 34.42,34.29 34.18,34.29 30.23,30.33 30.23,29.2 27.37,26.34 27.37,18.52 28.41,17.48 30.31,17.48 30.69,17.1 30.69,14.05 30.57,13.92 29.93,13.92 29.8,14.05 29.8,15.57 29.68,15.7 29.3,15.7 29.17,15.57 29.17,13.29 29.3,13.16 30.57,13.16 30.69,13.03 30.69,12.48 v9(30.9,12.27)
  IN4 w0.076: v2(27.54,13.75) 27.21,13.75 26.92,14.04 25.55,14.04 24.42,12.91 23.43,12.91 23.35,12.83 23.35,12.68 23.28,12.6 23.12,12.6 23.05,12.68 23.05,12.83 22.97,12.91 22.79,12.91 v5(22.62,12.73) 22.34,12.73 22.23,12.63 21.73,12.63 21.5,12.86 18.02,12.86 17.5,13.37 v2(16.01,13.37) ; v2(49.9,13.75) 49.57,13.75 49.27,14.04 47.9,14.04 46.77,12.91 45.78,12.91 45.7,12.83 45.7,12.68 45.63,12.6 45.48,12.6 45.4,12.68 45.4,12.83 45.32,12.91 45.15,12.91 v5(44.97,12.73) 44.69,12.73 44.59,12.63 44.08,12.63 43.85,12.86 40.09,12.86 39.58,13.37 v2(38.36,13.37)
  IN4 w0.165: v5(52.84,41.08) 52.88,41.04 v2(53.32,41.04)
  BOTTOM w0.127: v2(49.9,13.75) 49.9,13.73 U21.N7 ; U19.N7 27.54,13.73 v2(27.54,13.75)
M_A_A13: length 115.5
  TOP w0.089: R415.2 36.48,9.4 v9(36.23,9.4)
  IN1 w0.076: v5(24.7,9.58) 24.8,9.68 30.95,9.68 31.35,9.28 36.1,9.28 v9(36.23,9.4) 42.83,9.4 43.47,10.04 44.05,10.04 44.41,10.39 46.24,10.39 v5(47.05,9.58)
  IN2 w0.165: v9(36.23,9.4) 37.81,9.4 37.93,9.53 37.93,11.05 37.81,11.18 37.42,11.18 37.3,11.05 37.3,10.32 37.17,10.19 36.79,10.19 36.66,10.32 36.66,14.56 36.41,14.81 36.41,15.19 36.69,15.47 37.68,15.47 38.15,15 39.68,15 40.15,15.47 41.3,15.47 42.38,14.39 44.97,14.39 45.09,14.52 45.09,15.92 45.22,16.04 45.55,16.04 45.68,15.92 45.68,14.94 45.81,14.81 46.14,14.81 46.26,14.94 46.26,16.06 46.49,16.29 47.08,16.29 47.2,16.16 47.2,15.7 47.33,15.57 47.79,15.57 47.91,15.7 47.91,19.73 49.4,21.21 51.58,21.21 61.1,30.73 61.1,40.95 59.62,42.42 57.46,42.42 v5(56.91,41.87)
  IN4 w0.076: v2(52.74,10.97) 52.74,10.98 52.46,11.26 49.18,11.26 47.51,9.58 v5(47.05,9.58) 47.03,9.61 45.3,9.61 45.12,9.43 43.11,9.43 42.07,10.47 v2(42,10.47) ; v2(30.39,10.97) 30.39,10.98 30.11,11.26 26.83,11.26 25.16,9.58 v5(24.7,9.58) 24.42,9.86 22.79,9.86 22.36,9.43 21.2,9.43 20.65,9.98 20.48,9.98 20.36,9.87 20.24,9.87 20.15,9.96 20.15,10.08 20.26,10.2 20.26,10.35 20.14,10.47 v2(19.64,10.47)
  IN4 w0.165: v5(56.91,41.87) 57.23,42.19 v2(57.29,42.19)
  BOTTOM w0.076: U20.T3 41.56,10.9 v2(42,10.47) ; v2(19.64,10.47) 19.21,10.9 U18.T3
M_A_A14: length 119.7
  TOP w0.089: v9(32.65,8.31) 32.57,8.39 v6(31.86,8.39) 30.34,8.39 30.16,8.21 R421.2
  IN1 w0.076: v5(44.61,8.64) 44.59,8.67 43.82,8.67 43.47,8.31 v9(32.65,8.31) 27.96,8.31 27.89,8.39 27.89,8.44 27.81,8.51 27.66,8.51 27.58,8.44 27.58,8.39 27.51,8.31 27.36,8.31 27.28,8.39 27.28,8.44 27.2,8.51 27.05,8.51 26.97,8.44 26.97,8.39 26.9,8.31 26.75,8.31 26.67,8.39 26.67,8.44 26.59,8.51 26.44,8.51 26.36,8.44 26.36,8.39 26.29,8.31 26.14,8.31 26.06,8.39 26.06,8.44 25.98,8.51 25.83,8.51 25.76,8.44 25.76,8.39 25.68,8.31 25.53,8.31 25.45,8.39 25.45,8.44 25.37,8.51 25.22,8.51 25.15,8.44 25.15,8.39 25.07,8.31 24.92,8.31 24.84,8.39 24.84,8.44 24.76,8.51 24.61,8.51 24.54,8.44 24.54,8.39 24.46,8.31 24.31,8.31 24.23,8.39 24.23,8.44 24.15,8.51 24,8.51 23.93,8.44 23.93,8.39 23.85,8.31 23.07,8.31 22.74,8.64 v5(22.26,8.64)
  IN2 w0.089: 53.21,41.29 53.21,41.1 53.2,41.05 53.07,40.72 52.92,40.57 v5(52.79,40.57)
  IN2 w0.165: v9(32.65,8.31) 31.1,9.86 27.49,9.86 27.33,10.02 27.33,10.96 27.16,11.13 26.82,11.13 26.65,10.96 26.65,10.02 26.49,9.86 26.12,9.86 25.87,10.11 25.87,18.5 24.91,19.45 24.91,27.06 38.69,40.85 41.49,40.85 42.38,41.74 46.31,41.74 46.89,41.16 50.15,41.16 50.55,41.56 51.62,41.56 51.99,41.93 52.65,41.93 53.21,41.37 53.21,41.29
  IN4 w0.076: v2(16.01,10.97) 17.16,10.97 17.45,10.69 18.59,10.69 20.63,8.64 v5(22.26,8.64) 22.46,8.64 22.62,8.49 23.72,8.49 23.79,8.56 23.79,8.67 23.87,8.74 24.02,8.74 24.1,8.67 24.1,8.56 24.17,8.49 24.33,8.49 24.4,8.56 24.4,8.67 24.48,8.74 24.63,8.74 24.71,8.67 24.71,8.56 24.78,8.49 25.28,8.49 26.88,10.09 26.88,10.88 26.98,10.97 v2(27.19,10.97) ; v2(38.36,10.97) 39.51,10.97 39.8,10.69 40.94,10.69 42.99,8.64 v5(44.61,8.64) 44.82,8.64 44.97,8.49 46.07,8.49 46.14,8.56 46.14,8.67 46.22,8.74 46.37,8.74 46.45,8.67 46.45,8.56 46.52,8.49 46.68,8.49 46.75,8.56 46.75,8.67 46.83,8.74 46.98,8.74 47.06,8.67 47.06,8.56 47.13,8.49 47.63,8.49 49.24,10.09 49.24,10.88 49.33,10.97 v2(49.54,10.97)
  IN4 w0.165: v2(52.44,40.39) 52.61,40.39 v5(52.79,40.57)
M_A_A15: length 116.9
  TOP w0.089: v9(30.31,12.65) 30.31,13.3 R424.2
  IN1 w0.076: v5(21.98,12.98) 21.35,12.98 21.19,13.14 21.19,13.7 21.35,13.85 22.18,13.85 22.36,13.67 22.36,13.29 22.44,13.21 22.67,13.21 22.74,13.29 22.74,13.7 22.82,13.77 23.05,13.77 23.12,13.7 23.12,13.29 23.2,13.21 23.43,13.21 23.5,13.29 23.5,13.85 23.58,13.92 23.81,13.92 23.89,13.85 23.89,13.29 23.96,13.21 25.59,13.21 26.2,12.6 30.26,12.6 v9(30.31,12.65) 30.36,12.6 41.82,12.6 42.2,12.98 v5(44.33,12.98)
  IN2 w0.165: v9(30.31,12.65) 28.28,12.65 27.14,13.8 27.14,16.09 26.25,16.98 26.25,20.2 26.12,20.32 25.4,20.32 25.28,20.45 25.28,20.78 25.4,20.91 26.12,20.91 26.25,21.04 26.25,21.32 26.12,21.44 25.4,21.44 25.28,21.57 25.28,21.92 25.4,22.05 26.12,22.05 26.25,22.18 26.25,22.44 26.09,22.6 25.4,22.6 25.28,22.73 25.28,23.02 25.4,23.15 26.09,23.15 26.25,23.31 26.25,23.54 26.09,23.7 25.4,23.7 25.28,23.82 25.28,24.11 25.4,24.24 26.09,24.24 26.25,24.4 26.25,24.63 26.09,24.79 25.4,24.79 25.28,24.91 25.28,25.21 25.4,25.33 26.09,25.33 26.25,25.49 26.25,25.86 26.12,25.99 25.4,25.99 25.28,26.12 25.28,26.91 25.74,27.37 25.97,27.37 26.33,27.01 26.51,27.01 26.72,27.22 26.72,27.4 26.35,27.76 26.35,27.99 26.51,28.15 26.74,28.15 27.1,27.78 27.28,27.78 27.49,27.99 27.49,28.17 27.13,28.53 27.13,28.76 38.85,40.48 41.64,40.48 42.53,41.37 45.29,41.37 45.93,40.72 48.23,40.72 49.25,39.7 49.7,39.7 50.27,40.26 50.56,40.26 50.87,40.57 50.87,40.83 51.21,41.17 52.07,41.17 v5(52.41,41.51)
  IN4 w0.076: v2(16.01,14.17) 16.51,13.67 17.64,13.67 18.22,13.09 21.65,13.09 21.75,12.98 v5(21.98,12.98) 21.98,13.11 22.02,13.15 24.28,13.15 25.38,14.25 27.11,14.25 v2(27.19,14.17) ; v2(38.36,14.17) 39.36,14.17 40.45,13.09 44,13.09 44.1,12.98 v5(44.33,12.98) 44.33,13.11 44.37,13.15 46.63,13.15 47.74,14.25 49.46,14.25 v2(49.54,14.17)
  IN4 w0.165: v2(52.39,41.04) 52.39,41.49 v5(52.41,41.51)
M_A_BS0: length 123
  TOP w0.076: 36.61,12.91 v6(36.05,13.47)
  TOP w0.089: v9(36.1,14.08) 36.05,14.03 v6(36.05,13.47) ; R429.2 36.61,12.91
  IN1 w0.076: v5(24.39,15.14) 24.88,15.14 25.28,14.74 28.57,14.74 28.65,14.66 28.65,14.56 28.72,14.48 28.88,14.48 28.95,14.56 28.95,14.66 29.03,14.74 29.18,14.74 29.26,14.66 29.26,14.56 29.33,14.48 29.49,14.48 29.56,14.56 29.56,14.66 29.64,14.74 29.79,14.74 29.87,14.66 29.87,14.56 29.94,14.48 30.1,14.48 30.17,14.56 30.17,14.66 30.25,14.74 30.4,14.74 30.48,14.66 30.48,14.56 30.55,14.48 30.71,14.48 30.78,14.56 30.78,14.66 30.86,14.74 31.01,14.74 31.09,14.66 31.09,14.56 31.16,14.48 31.31,14.48 31.39,14.56 31.39,14.66 31.47,14.74 31.62,14.74 31.7,14.66 31.7,14.56 31.77,14.48 31.92,14.48 32,14.56 32,14.66 32.08,14.74 32.23,14.74 32.31,14.66 32.31,14.56 32.38,14.48 32.53,14.48 32.61,14.56 32.61,14.66 32.69,14.74 32.84,14.74 32.91,14.66 32.91,14.56 32.99,14.48 33.14,14.48 33.22,14.56 33.22,14.66 33.3,14.74 33.45,14.74 33.52,14.66 33.52,14.56 33.6,14.48 33.75,14.48 33.83,14.56 33.83,14.66 33.91,14.74 34.06,14.74 34.13,14.66 34.13,14.56 34.21,14.48 34.36,14.48 34.44,14.56 34.44,14.66 34.52,14.74 34.67,14.74 34.74,14.66 34.74,14.56 34.82,14.48 34.97,14.48 35.05,14.56 35.05,14.66 35.12,14.74 35.37,14.74 36.03,14.08 v9(36.1,14.08) 36.31,14.08 36.41,14.18 36.41,14.63 36.51,14.74 36.66,14.74 36.76,14.63 36.76,14.18 36.87,14.08 37.58,14.08 37.68,14.18 37.68,14.45 37.78,14.56 37.93,14.56 38.03,14.45 38.03,14.15 38.11,14.08 38.27,14.08 38.37,14.18 38.37,14.34 38.46,14.43 38.59,14.43 38.67,14.34 38.67,14.2 38.75,14.13 38.9,14.13 38.98,14.2 38.98,14.28 39.06,14.36 39.21,14.36 39.28,14.28 39.28,14.2 39.36,14.13 39.51,14.13 39.59,14.2 39.59,14.28 39.66,14.36 39.82,14.36 39.89,14.28 39.89,14.2 39.97,14.13 41.39,14.13 41.49,14.23 41.49,14.41 41.62,14.53 44.59,14.53 45.2,15.14 45.37,15.14 45.45,15.22 45.45,15.57 45.53,15.65 45.68,15.65 45.76,15.57 45.76,15.22 45.83,15.14 46.01,15.14 46.09,15.22 46.09,15.6 46.14,15.65 46.36,15.65 46.42,15.6 46.42,15.22 46.49,15.14 v5(46.75,15.14)
  IN2 w0.165: v9(36.1,14.08) 35.98,14.2 35.98,14.81 35.85,14.94 35.47,14.94 35.27,15.14 35.27,16.77 35.7,17.2 35.7,17.57 37.22,19.09 37.22,20.45 42.34,25.57 43.52,25.57 43.67,25.72 43.67,26.9 43.8,27.03 44.13,27.03 44.26,26.9 44.26,25.7 44.38,25.57 44.71,25.57 44.84,25.7 44.84,27.82 44.97,27.95 45.26,27.95 45.39,27.82 45.39,25.7 45.51,25.57 45.83,25.57 45.96,25.7 45.96,27.22 46.09,27.35 46.39,27.35 46.52,27.22 46.52,25.7 46.64,25.57 46.98,25.57 47.11,25.7 47.11,26.89 47.24,27.02 47.55,27.02 47.68,26.89 47.68,25.7 47.81,25.57 48.13,25.57 48.25,25.7 48.25,26.86 48.41,27.02 48.64,27.02 48.8,26.86 48.8,26.24 48.93,26.12 49.22,26.12 49.34,26.24 49.34,26.86 49.5,27.02 49.87,27.02 50.03,26.86 50.03,26.25 50.19,26.09 50.42,26.09 50.58,26.25 50.58,26.86 50.74,27.02 50.96,27.02 51.12,26.86 51.12,26.25 51.28,26.09 51.51,26.09 51.67,26.25 51.67,26.86 51.83,27.02 52.22,27.02 58.26,33.06 58.26,37.76 57.26,38.76 57.26,40.26 v5(56.83,40.7)
  IN4 w0.076: v2(31.19,14.17) 30.88,14.48 29.7,14.48 29.07,15.12 24.42,15.12 v5(24.39,15.14) 24.32,15.22 24.14,15.22 24.06,15.14 24.06,14.71 23.99,14.63 23.78,14.63 23.71,14.71 23.71,15.14 23.63,15.22 23.4,15.22 23.34,15.16 23.34,14.7 23.25,14.61 23.05,14.61 23,14.66 23,15.02 22.92,15.09 22.67,15.09 22.59,15.02 22.59,14.71 22.49,14.61 22.18,14.61 21.98,14.81 21.85,14.81 21.21,14.17 21.1,14.17 21.02,14.25 20.81,14.25 20.73,14.17 20.56,14.17 20.48,14.25 20.3,14.25 20.22,14.17 v2(20.01,14.17) ; v2(53.54,14.17) 53.54,14.32 53.38,14.48 52.05,14.48 51.42,15.12 46.77,15.12 v5(46.75,15.14) 46.64,15.24 46.44,15.24 46.39,15.19 46.39,14.66 46.34,14.61 46.14,14.61 46.06,14.69 46.06,15.14 45.98,15.22 45.76,15.22 45.69,15.16 45.69,14.7 45.6,14.61 45.4,14.61 45.35,14.66 45.35,15.02 45.27,15.09 45.02,15.09 44.94,15.02 44.94,14.71 44.84,14.61 44.51,14.61 44.33,14.79 44.13,14.79 43.51,14.17 43.42,14.17 43.34,14.25 43.14,14.25 43.06,14.17 42.9,14.17 42.82,14.25 42.6,14.25 42.52,14.17 v2(42.36,14.17)
  IN4 w0.165: v5(56.83,40.7) 57.12,40.98 v2(57.12,41.04)
M_A_BS1: length 119.4
  TOP w0.089: v9(35.62,11.99) 35.82,12.2 v6(36.1,12.2) 36.73,12.2 R428.2
  IN1 w0.076: v5(44.16,12.22) 42.43,12.22 42.38,12.17 42.38,11.74 42.28,11.64 42.02,11.64 41.92,11.74 41.92,11.94 41.87,11.99 41.67,11.99 41.59,11.92 41.59,11.74 41.49,11.64 41.3,11.64 41.22,11.71 41.22,11.88 41.15,11.96 41,11.96 40.92,11.88 40.92,11.71 40.84,11.64 40.69,11.64 40.61,11.71 40.61,11.88 40.54,11.96 40.39,11.96 40.31,11.88 40.31,11.71 40.23,11.64 40.06,11.64 39.98,11.71 39.98,11.88 39.9,11.96 39.75,11.96 39.67,11.88 39.67,11.71 39.6,11.64 39.45,11.64 39.37,11.71 39.37,11.88 39.29,11.96 39.14,11.96 39.06,11.88 39.06,11.71 38.99,11.64 38.84,11.64 38.76,11.71 38.76,11.88 38.68,11.96 38.53,11.96 38.46,11.88 38.46,11.71 38.38,11.64 38.23,11.64 38.15,11.71 38.15,11.88 38.07,11.96 37.92,11.96 37.85,11.88 37.85,11.71 37.77,11.64 37.62,11.64 37.54,11.71 37.54,11.88 37.46,11.96 37.31,11.96 37.24,11.88 37.24,11.71 37.16,11.64 37.01,11.64 36.93,11.71 36.93,11.88 36.85,11.96 36.7,11.96 36.63,11.88 36.63,11.71 36.55,11.64 36.4,11.64 36.32,11.71 36.32,11.88 36.25,11.96 36.09,11.96 36.02,11.88 36.02,11.71 35.94,11.64 35.77,11.64 35.62,11.79 v9(35.62,11.99) 30.82,11.99 30.46,11.63 26.23,11.63 25.41,12.45 23.45,12.45 23.23,12.22 v5(21.8,12.22)
  IN2 w0.165: v5(56.83,40.05) 56.83,38.74 57.9,37.67 57.9,33.22 57.34,32.66 57.09,32.66 56.55,33.2 56.08,33.2 55.76,32.89 55.76,31.08 52.07,27.39 50.52,27.39 50.39,27.51 50.39,29.3 50.26,29.43 49.95,29.43 49.82,29.3 49.82,27.51 49.69,27.39 49.36,27.39 49.24,27.51 49.24,29.3 49.11,29.43 48.78,29.43 48.65,29.3 48.65,27.89 48.52,27.77 48.19,27.77 48.07,27.89 48.07,29.3 47.94,29.43 47.61,29.43 47.48,29.3 47.48,27.89 47.36,27.77 47.03,27.77 46.9,27.89 46.9,29.3 46.77,29.43 46.47,29.43 46.34,29.3 46.34,27.84 46.21,27.72 45.88,27.72 45.76,27.84 45.76,28.9 45.59,29.06 45.31,29.06 36.85,20.61 36.85,19.14 35.42,17.71 35.42,17.33 35,16.91 35,14.73 36.15,13.57 36.15,11.64 36,11.49 35.8,11.49 35.62,11.66 v9(35.62,11.99)
  IN4 w0.076: v2(49.11,13.77) 47.99,13.77 46.59,12.37 46.34,12.37 46.26,12.45 46.26,12.65 46.19,12.73 46.03,12.73 45.96,12.65 45.96,12.45 45.88,12.37 44.31,12.37 v5(44.16,12.22) 44.1,12.22 43.71,12.62 39.75,12.62 39.28,13.09 37.85,13.09 v2(37.56,13.37) ; v2(15.21,13.37) 15.5,13.09 17.28,13.09 17.75,12.62 21.36,12.62 21.75,12.22 v5(21.8,12.22) 21.96,12.37 23.53,12.37 23.61,12.45 23.61,12.65 23.68,12.73 23.84,12.73 23.91,12.65 23.91,12.45 23.99,12.37 24.24,12.37 25.64,13.77 v2(26.76,13.77)
  IN4 w0.165: v5(56.83,40.05) 57.16,40.38 v2(57.16,40.39)
  BOTTOM w0.076: v2(26.76,13.77) 26.76,13.74 U19.N8
  BOTTOM w0.127: v2(49.11,13.77) 49.11,13.74 U21.N8
