# Allegro board dad13cmbag0-g-roger-165XL.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_B_DQ29: length 32.8
  IN4 w0.089: v2(62.56,44.15) 62.56,44.28 62.43,44.4 62.24,44.4 62.11,44.28 62.11,44.02 62.32,43.82 62.32,43.64 62.11,43.44 62.11,41.99 62.93,41.18 63.1,41.18 63.64,40.64 63.64,38.54
  IN4 w0.152: 63.64,38.54 63.64,36.91 62.51,35.78 62.51,35.12 62.95,34.68 62.95,34.37 62.51,33.93 62.51,31.74 65.06,29.19 65.06,28.27 67.46,25.87 67.46,25.44 66.93,24.91 66.93,24.73 67.15,24.5 67.28,24.5 67.73,24.95 67.91,24.95 68.12,24.73 68.12,24.55 67.75,24.19 67.75,23.88 67.88,23.75 68.46,23.75 68.59,23.63 68.59,21.37 68.72,21.24 69.07,21.24 69.2,21.37 69.2,22.31 69.33,22.43 69.8,22.43 70.06,22.17 v2(70.2,22.17)
M_B_DQ30: length 33.3
  IN4 w0.089: v2(63.51,45.45) 63.18,45.12 63.18,44.73 63.41,44.51 63.71,44.51 64.3,43.92 64.3,42.57 65.61,41.26 65.89,41.26 66.15,41
  IN4 w0.152: v2(75,22.97) 75,22.71 75.86,21.85 76.04,21.85 76.37,22.17 76.37,22.35 75.22,23.5 75.22,23.95 75.04,24.13 74.61,24.13 74.47,23.99 74.47,23.68 74.34,23.55 73.85,23.55 73.72,23.68 73.72,24.84 66,32.56 66,38.54 66.25,38.79 66.25,39.93 66.15,40.03 66.15,41
M_B_DQ31: length 33.4
  IN4 w0.089: 66.41,41.23 66.41,41.3 65.69,42.02 65.69,42.32 64.6,43.41 64.6,44 63.8,44.8 v2(63.51,44.8)
  IN4 w0.152: 66.41,41.23 66.41,40.14 66.51,40.03 66.51,38.61 66.38,38.49 66.38,32.77 74.53,24.62 75.09,24.62 75.6,24.11 75.6,23.66 76.06,23.19 76.4,23.19 77.26,22.34 77.26,22.16 76.23,21.13 76.05,21.13 v2(74.2,22.97)
M_B_DQ32: length 32.2
  IN3 w0.152: v2(81.38,18.97) 81.38,18.11 81.25,17.99 80.99,17.99 80.86,18.11 80.86,18.84 80.73,18.97 79.42,18.97 76.29,22.1 76.29,23.19 75.14,24.34 74.55,24.34 74.25,24.63 74.25,25.23 73.87,25.61 73.25,25.61 72.76,26.1 72.76,26.73 72.4,27.08 71.8,27.08 71.38,27.5 71.38,28.1 70.95,28.53 70.38,28.53 69.94,28.97 69.94,29.54 69.56,29.93 68.96,29.93 68.21,30.68 68.21,31.91 67.9,32.21 67.23,32.21 67.07,32.38 67.07,33.05 66.23,33.89 66.23,36.33 64.37,38.18 v2(64.37,39.09)
M_B_DQ33: length 32.5
  IN3 w0.089: 64.73,38.61 64.73,39.27 64.37,39.63 v2(64.37,39.74)
  IN3 w0.152: v2(82.18,18.97) 82.18,19.21 82.03,19.35 80.64,19.35 79.94,20.05 79.05,20.05 78.56,20.54 78.56,20.75 78.73,20.92 78.73,21.13 78.48,21.39 78.26,21.39 78.1,21.22 77.88,21.22 77.63,21.47 77.63,21.69 77.79,21.85 77.79,22.07 77.54,22.32 77.33,22.32 77.16,22.15 76.95,22.15 76.67,22.43 76.67,23.35 74.03,25.99 73.41,25.99 73.14,26.26 73.14,26.88 72.56,27.46 71.96,27.46 71.76,27.66 71.76,28.25 71.11,28.91 70.54,28.91 70.32,29.13 70.32,29.7 69.71,30.31 69.17,30.31 68.59,30.89 68.59,32.06 66.61,34.05 66.61,36.75 65.93,37.43 65.61,37.43 64.73,38.31 64.73,38.61
M_B_DQ34: length 31.3
  IN3 w0.152: v2(85.38,19.77) 84.98,20.17 84.67,20.17 84.26,19.77 84.06,19.77 83.83,19.99 83.83,20.15 84.29,20.61 84.29,20.86 84.17,20.98 81.9,20.98 72.02,30.86 72.02,31.1 71.24,31.88 70.33,31.88 70.16,32.05 70.16,32.96 68.44,34.69 68.44,37.27 66.62,39.09 v2(65.72,39.09)
M_B_DQ35: length 33.1
  IN3 w0.152: v2(85.38,17.37) 85.86,17.85 85.86,18.7 85.79,18.78 85.79,19.92 84.31,21.39 82.03,21.39 72.4,31.02 72.4,31.35 71.49,32.26 70.9,32.26 70.55,32.62 70.55,33.2 69.02,34.73 69.02,37.27 66.71,39.58 65.88,39.58 v2(65.72,39.74)
M_B_DQ36: length 33.6
  IN3 w0.089: 64.04,38.64 63.99,38.69 63.99,40.29 64.09,40.39 v2(64.37,40.39)
  IN3 w0.152: 64.04,38.64 64.04,37.98 65.85,36.17 65.85,34.98 65.49,34.63 65.49,33.98 66.66,32.81 66.66,32.25 67.08,31.83 67.68,31.83 67.83,31.68 67.83,30.52 68.8,29.54 69.3,29.54 69.56,29.29 69.56,28.79 70.2,28.15 70.79,28.15 71,27.94 71,27.34 71.65,26.7 72.15,26.7 72.37,26.48 72.37,25.92 73.07,25.23 73.69,25.23 73.87,25.04 73.87,24.47 75.91,22.44 75.91,21.8 79.21,18.5 80.35,18.5 80.48,18.37 80.48,17.5 80.6,17.37 v2(81.38,17.37)
M_B_DQ37: length 34.8
  IN3 w0.089: v2(64.37,41.04) 64.73,40.68 64.73,39.91 64.96,39.68 64.96,38.82
  IN3 w0.152: 64.96,38.82 65.06,38.71 65.06,38.43 65.65,37.84 66.06,37.84 67.04,36.86 67.04,34.15 68.97,32.22 68.97,31.05 69.33,30.69 70.44,30.69 70.83,30.31 70.83,29.77 80.86,19.73 82.39,19.73 82.76,19.36 82.76,16.84 82.64,16.72 82.31,16.72 82.18,16.84 v2(82.18,17.37)
M_B_DQ38: length 33
  IN3 w0.152: v2(65.62,40.39) 65.62,40.34 65.92,40.03 67.04,40.03 69.4,37.67 69.4,34.88 70.25,34.04 70.99,34.04 71.46,33.57 71.46,32.83 72.96,31.32 73.59,31.32 73.87,31.04 73.87,30.48 74.56,29.8 75.04,29.8 75.27,29.57 75.27,29.21 76.01,28.47 76.01,27.95 82.19,21.77 84.47,21.77 86.18,20.06 v2(86.18,18.97)
M_B_DQ39: length 35
  IN3 w0.152: v2(65.62,40.8) 65.8,40.62 65.82,40.62 66.08,40.37 67.52,40.37 69.78,38.1 69.78,35.04 70.4,34.42 71.14,34.42 71.84,33.72 71.84,32.98 73.02,31.81 73.65,31.81 74.25,31.2 74.25,30.69 74.77,30.18 75.28,30.18 75.69,29.76 75.69,29.33 76.46,28.55 76.46,28.04 82.35,22.15 84.63,22.15 86.57,20.21 86.57,18.57 v2(86.18,18.17)
  BOTTOM w0.216: U16.AU21 65.62,40.8 v2(65.62,40.8)
M_B_DQ40: length 28.8
  IN4 w0.152: v2(82.18,20.57) 82.07,20.68 80.86,20.68 80.47,21.07 79.59,21.07 79.49,20.97 79.28,20.97 79.02,21.22 79.02,21.43 79.13,21.54 79.13,21.75 78.88,22 78.66,22 78.56,21.9 78.34,21.9 78.09,22.15 78.09,22.37 78.19,22.47 78.19,22.69 77.94,22.94 77.73,22.94 77.62,22.83 77.41,22.83 77.16,23.09 77.16,23.3 77.26,23.4 77.26,23.62 77.01,23.87 76.79,23.87 76.69,23.77 76.47,23.77 76.22,24.02 76.22,24.24 76.32,24.34 76.32,24.55 75.8,25.07 74.73,25.07 66.89,32.91 66.89,37.34 66.8,37.43 v2(66.8,39.09)
M_B_DQ41: length 29.7
  IN4 w0.089: v2(66.8,39.74) 67.09,39.45 67.09,38.03 67.22,37.9
  IN4 w0.152: v2(81.38,21.37) 81.16,21.37 80.99,21.54 80.99,22.18 80.35,22.81 79.72,22.81 79.33,23.19 79.33,23.83 78.93,24.23 78.08,24.23 77.73,23.87 77.55,23.87 77.28,24.14 77.28,24.32 77.72,24.76 77.72,24.94 77.46,25.2 77.28,25.2 76.84,24.77 76.65,24.77 75.96,25.46 74.89,25.46 74.64,25.71 74.64,26.42 74.38,26.67 73.67,26.67 73.37,26.98 73.37,27.69 73.16,27.89 72.45,27.89 72.1,28.25 72.1,29.29 71.78,29.6 70.74,29.6 67.22,33.12 67.22,37.9
M_B_DQ42: length 28
  IN4 w0.152: v2(85.38,21.37) 85.04,21.04 84.34,21.04 83.38,21.99 83.38,23.62 78.19,28.81 76.43,28.81 73.66,31.58 71.94,31.58 69.25,34.26 69.25,38.05 68.22,39.09 v2(68.15,39.09)
M_B_DQ43: length 29.1
  IN4 w0.152: v2(68.15,39.74) 68.15,39.51 69.63,38.03 69.63,34.42 72.09,31.96 73.81,31.96 76.59,29.19 78.34,29.19 83.76,23.77 83.76,22.18 83.96,21.98 85.99,21.98 86.18,21.79 v2(86.18,21.37)
M_B_DQ44: length 29.4
  IN4 w0.089: 67.51,38.52 67.45,38.59 67.45,39.72 67.2,39.97 67.2,40.18 66.99,40.39 v2(66.91,40.39)
  IN4 w0.152: 67.51,38.52 68.26,37.77 68.26,33.16 71.06,30.36 72.83,30.36 73.24,29.95 73.24,29.24 73.57,28.91 74.28,28.91 74.89,28.3 74.89,27.59 75.07,27.41 75.76,27.41 75.91,27.26 76.06,27.26 76.41,27.61 76.64,27.61 76.85,27.4 76.85,27.21 76.25,26.61 76.25,26.43 76.46,26.22 76.64,26.22 77.63,27.21 78.1,27.21 82.18,23.13 v2(82.18,22.97)
M_B_DQ45: length 30.5
  IN4 w0.089: v2(66.91,41.04) 66.63,40.76 66.63,40.29 66.91,40.01 66.91,40 67.27,39.64 67.27,38.21 67.47,38
  IN4 w0.152: v2(81.38,22.17) 81.38,22.8 80.99,23.19 80.49,23.19 79.97,23.72 79.97,24.21 79.46,24.72 78.95,24.72 78.7,24.97 78.7,25.48 78.34,25.84 75.76,25.84 75.47,26.13 75.47,26.3 75.81,26.64 75.81,26.82 75.6,27.03 75.42,27.03 75.12,26.73 74.87,26.73 74.12,27.47 74.12,27.67 74.46,28.01 74.46,28.19 74.24,28.41 74.06,28.41 73.75,28.1 73.5,28.1 72.86,28.74 72.86,29.79 72.67,29.98 70.9,29.98 67.95,32.93 67.95,37.52 67.47,38
M_B_DQ46: length 29.4
  IN4 w0.152: v2(86.18,22.97) 85.79,22.59 84.67,22.59 84.14,23.11 84.14,24.07 82.38,25.83 82.38,26.37 82.13,26.62 81.59,26.62 80.99,27.23 80.99,27.8 80.66,28.12 80.09,28.12 79.59,28.62 79.59,29.16 79.18,29.57 76.74,29.57 73.97,32.34 72.25,32.34 69.99,34.61 69.99,38.33 68.15,40.17 v2(68.15,40.39)
M_B_DQ47: length 30
  IN4 w0.152: v2(68.39,40.77) 68.44,40.72 68.44,40.56 71.1,37.89 71.1,35.55 71.23,35.42 71.23,34.59 72.2,33.62 72.2,32.93 72.41,32.72 74.13,32.72 76.9,29.95 79.36,29.95 79.97,29.34 79.97,28.78 80.25,28.5 80.83,28.5 81.37,27.97 81.37,27.39 81.75,27 82.31,27 82.76,26.55 82.76,25.99 83.6,25.15 83.78,25.15 84.17,25.54 84.35,25.54 84.6,25.29 84.6,25.11 84.21,24.72 84.21,24.54 84.52,24.23 84.52,23.27 84.82,22.97 v2(85.38,22.97)
  BOTTOM w0.216: U16.AU17 68.39,40.77 v2(68.39,40.77)
M_B_DQ48: length 42.7
  IN3 w0.152: v2(66.26,42.2) 66.82,42.75 67.65,42.75 67.82,42.92 69.66,42.92 74.99,37.6 75.42,37.6 75.7,37.32 75.7,36.1 75.91,35.89 76.51,35.89 79.08,33.32 79.08,32.54 79.21,32.41 80.56,32.41 81.11,31.86 81.11,31.29 81.33,31.07 81.87,31.07 82.13,30.81 82.13,30.27 82.48,29.93 83.02,29.93 83.27,29.67 83.27,29.13 83.62,28.78 84.2,28.78 91.29,21.7 93.19,21.7 94.54,20.35 94.93,20.35 95.36,20.78 95.55,20.78 v2(96.56,19.77)
M_B_DQ49: length 43
  IN3 w0.089: 68.97,41.08 68.72,41.33 67.3,41.33 67.25,41.38 65.95,41.38 65.31,42.02 v2(65.31,42.2)
  IN3 w0.152: v2(93.36,18.97) 93.36,19.31 92.54,20.12 90.55,20.12 89.53,21.14 89.36,21.14 88.92,20.7 88.75,20.7 88.51,20.94 88.51,21.12 88.95,21.56 88.95,21.72 84.25,26.42 82.55,26.42 79.17,29.8 78.19,29.8 77.94,30.05 77.94,30.43 77.52,30.85 77.52,31.33 77.29,31.56 76.81,31.56 76.59,31.79 76.59,32.27 76.36,32.49 75.88,32.49 75.65,32.72 75.65,33.2 75.41,33.45 74.83,33.45 74.24,34.04 73.67,34.04 73.23,34.47 73.01,34.47 72.25,35.23 72.25,35.41 72.37,35.54 72.91,35.54 73.07,35.7 73.07,35.89 72.65,36.3 72.65,37.39 68.97,41.08
M_B_DQ50: length 45.2
  IN3 w0.152: v2(66.26,44.8) 66.5,44.56 67.35,44.56 68.11,43.79 69.71,43.79 75.02,38.49 76.57,38.49 79.33,35.72 79.33,35.11 81.22,33.22 81.44,33.22 81.56,33.33 81.77,33.33 81.99,33.12 81.99,32.9 81.87,32.79 81.87,32.57 82.14,32.3 82.36,32.3 82.48,32.42 82.7,32.42 82.91,32.21 82.91,31.99 82.79,31.87 82.79,31.65 83.06,31.38 83.27,31.38 83.4,31.51 83.61,31.51 83.83,31.29 83.83,31.08 83.7,30.95 83.7,30.74 83.97,30.47 84.19,30.47 84.31,30.59 84.53,30.59 84.75,30.38 84.75,30.16 84.62,30.04 84.62,29.82 91.98,22.46 94.95,22.46 97.36,20.05 v2(97.36,18.97)
M_B_DQ51: length 45.3
  IN3 w0.089: 66.1,40.87 65.95,41.03 65.8,41.03 65.7,41.13 65.59,41.13 64.75,41.97 64.75,43.57 65.31,44.12 v2(65.31,44.15)
  IN3 w0.152: 66.1,40.87 66.33,40.64 67.9,40.64 70.24,38.31 70.24,35.23 70.59,34.88 71.33,34.88 72.55,33.66 72.97,33.66 73.7,32.92 73.7,32.4 73.95,32.15 74.48,32.15 74.68,31.94 74.68,31.42 74.89,31.21 75.41,31.21 75.62,31.01 75.62,30.49 75.82,30.28 76.35,30.28 76.55,30.07 76.55,29.55 76.76,29.35 77.28,29.35 77.61,29.01 78.83,29.01 79.1,28.74 79.1,28.53 79.01,28.44 79.01,28.22 79.26,27.97 79.47,27.97 79.56,28.06 79.78,28.06 80.03,27.81 80.03,27.59 79.94,27.5 79.94,27.29 80.19,27.03 80.41,27.03 80.5,27.12 80.71,27.12 80.96,26.87 80.96,26.66 80.88,26.57 80.88,26.35 81.13,26.1 81.34,26.1 81.43,26.19 81.65,26.19 82.18,25.66 83.93,25.66 87.84,21.75 87.84,21.57 87.46,21.19 87.46,20.91 88.44,19.93 89.66,19.93 90.23,19.36 91.81,19.36 92.19,18.97 v2(92.56,18.97)
M_B_DQ52: length 44.9
  IN3 w0.089: 66.28,41.1 66.18,41.2 65.87,41.2 65.03,42.04 65.03,43.29 65.24,43.5 v2(65.31,43.5)
  IN3 w0.152: v2(92.56,17.37) 92.91,17.72 92.91,19.13 92.3,19.74 90.39,19.74 89.82,20.31 88.6,20.31 87.97,20.94 87.97,21.16 88.4,21.6 88.4,21.72 84.09,26.04 82.39,26.04 79.01,29.42 77.75,29.42 77.35,29.81 77.35,30.39 77.1,30.64 76.53,30.64 76.35,30.82 76.35,31.39 76.16,31.57 75.59,31.57 75.41,31.75 75.41,32.32 75.23,32.51 74.66,32.51 74.48,32.69 74.48,33.26 74.3,33.44 73.72,33.44 73.12,34.04 72.88,34.04 71.32,35.6 71.32,38.27 68.64,40.95 66.43,40.95 66.28,41.1
M_B_DQ53: length 44.7
  IN3 w0.152: v2(96.56,17.37) 96.65,17.37 96.96,17.68 96.96,19.9 94.79,22.08 91.45,22.08 84.2,29.33 84.2,29.77 83.92,30.05 83.47,30.05 83.24,30.28 83.24,30.71 83.04,30.92 82.61,30.92 82.36,31.17 82.36,31.64 82.11,31.88 81.64,31.88 77,36.53 77,37.42 76.31,38.1 74.94,38.1 69.71,43.34 66.75,43.34 v2(66.26,42.85)
M_B_DQ54: length 46.7
  IN3 w0.152: v2(97.36,18.17) 97.5,18.17 97.77,18.45 97.77,20.17 95.1,22.84 92.26,22.84 91.91,23.19 91.91,24.03 91.4,24.54 90.56,24.54 90.13,24.97 90.13,25.81 89.76,26.18 88.92,26.18 85.58,29.52 85.58,30.56 85.2,30.94 84.72,30.94 84.5,31.16 84.5,31.65 84.24,31.92 83.74,31.92 83.36,32.3 83.36,32.8 83.09,33.06 82.6,33.06 82.28,33.38 82.28,33.9 81.43,34.75 80.91,34.75 76.72,38.94 75.02,38.94 69.75,44.21 68.48,44.21 67.68,45.01 66.7,45.01 v2(66.26,45.45)
M_B_DQ55: length 46.4
  IN3 w0.089: v2(65.36,45.45) 65.59,45.21 65.59,41.99 66.02,41.56 67.32,41.56 67.37,41.51 68.89,41.51
  IN3 w0.152: 68.89,41.51 69,41.51 73.03,37.47 73.03,37.21 73.74,36.5 73.74,35.09 75.01,33.83 75.7,33.83 79.29,30.24 79.5,30.24 79.66,30.4 79.88,30.4 80.13,30.15 80.13,29.93 79.97,29.77 79.97,29.56 80.22,29.31 80.44,29.31 80.6,29.47 80.81,29.47 81.06,29.21 81.06,29 80.9,28.84 80.9,28.62 81.15,28.37 81.37,28.37 81.53,28.53 81.74,28.53 82,28.28 82,28.06 81.84,27.9 81.84,27.69 82.01,27.52 83.19,27.52 83.89,26.83 84.47,26.83 90.8,20.5 92.7,20.5 93.8,19.4 93.8,18.88 93.61,18.69 93.61,17.63 v2(93.36,17.37)
M_B_DQ56: length 42.8
  IN4 w0.089: 69.35,40.92 68.86,41.41 67.62,41.41 66.94,42.09 66.94,43.31 67.12,43.5 v2(67.21,43.5)
  IN4 w0.152: v2(93.36,20.57) 92.92,21 92.92,23.3 89.24,26.98 87.72,26.98 86.52,28.18 82.88,28.18 82.61,28.45 82.61,28.66 82.89,28.94 82.89,29.16 82.64,29.41 82.43,29.41 82.15,29.13 81.93,29.13 81.68,29.38 81.68,29.6 81.96,29.88 81.96,30.09 81.71,30.35 81.49,30.35 81.21,30.06 81,30.06 80.6,30.46 80.6,30.69 80.88,30.96 80.88,31.18 80.65,31.41 80.43,31.41 80.2,31.17 77.41,31.17 73.9,34.68 73.16,34.68 72.86,34.98 72.86,37.42 69.35,40.92
M_B_DQ57: length 40.2
  IN4 w0.089: 69.73,41 69.13,41.61 67.8,41.61 67.52,41.89 67.52,42.92 67.43,43.01 67.3,43.01 67.21,42.92 v2(67.21,42.2)
  IN4 w0.152: v2(93.36,22.97) 93.36,23.4 88.82,27.94 88.59,27.94 88.09,27.44 87.91,27.44 87.7,27.65 87.7,27.83 88.1,28.22 88.1,28.43 87.97,28.56 84.13,28.56 80.55,32.14 79.79,32.14 79.64,31.98 79.64,31.65 79.54,31.55 79.13,31.55 79.03,31.65 79.03,31.98 78.88,32.14 78.5,32.14 78.34,31.98 78.34,31.67 78.23,31.55 77.81,31.55 77.68,31.68 77.68,32.01 77.56,32.14 76.98,32.14 73.93,35.19 73.93,36.8 69.73,41
M_B_DQ58: length 42.8
  IN4 w0.152: v2(68.17,45.45) 68.66,45.45 68.79,45.32 68.79,43.74 69.05,43.49 69.81,43.49 69.96,43.34 70.39,43.34 74.97,38.76 76.59,38.76 78.19,37.16 78.19,36.53 78.57,36.15 78.57,35.92 78.42,35.77 77.94,35.77 77.81,35.64 77.81,35.39 78.69,34.5 81.96,34.5 85.54,30.92 89.25,30.92 93.16,27 93.81,27 94.07,26.75 94.07,26.1 94.38,25.79 95.03,25.79 95.26,25.55 95.26,24.9 95.83,24.34 96.66,24.34 97.36,23.64 v2(97.36,22.97)
M_B_DQ59: length 42
  IN4 w0.089: v2(68.17,44.8) 68.17,44.8
  IN4 w0.152: v2(97.36,21.37) 96.94,21.79 96.94,22.85 96.94,23.23 96.81,23.35 95.57,23.35 95.34,23.58 95.34,24.29 89.09,30.54 85.39,30.54 81.8,34.12 78.49,34.12 77.2,35.41 77.2,37.57 76.49,38.28 74.99,38.28 70.27,43.01 69.83,43.01 69.67,43.17 68.73,43.17 68.51,43.39 68.51,44.45 68.17,44.8
M_B_DQ60: length 44.1
  IN4 w0.089: 68.82,40.54 68.67,40.7 68.67,40.9 68.51,41.06 67.42,41.06 66.58,41.89 66.58,44.82 v2(67.21,45.45)
  IN4 w0.152: v2(92.56,21.37) 91.62,22.31 91.41,22.31 91.28,22.18 91.1,22.18 90.81,22.47 90.81,22.65 91.1,22.93 91.1,23.11 90.81,23.4 90.63,23.4 90.32,23.09 90.14,23.09 89.86,23.38 89.86,23.56 90.18,23.88 90.18,24.06 89.89,24.35 89.71,24.35 89.37,24 89.19,24 88.9,24.29 88.9,24.47 89.23,24.8 89.23,24.98 88.94,25.27 88.76,25.27 88.45,24.95 88.27,24.95 87.98,25.24 87.98,25.42 88.14,25.58 88.14,25.79 87.86,26.06 83.92,26.06 79.57,30.41 77.09,30.41 73.71,33.79 72.68,33.79 71.68,34.79 71.68,35.63 71.49,35.82 71.49,37.88 68.82,40.54
M_B_DQ61: length 41.9
  IN4 w0.089: v2(67.21,44.15) 66.76,43.7 66.76,41.97 67.49,41.24 68.58,41.24 68.89,40.92
  IN4 w0.152: 68.89,40.92 72.45,37.37 72.45,34.7 72.93,34.22 73.82,34.22 77.25,30.79 79.73,30.79 82.73,27.8 84.57,27.8 84.69,27.67 84.69,26.75 84.82,26.62 85.18,26.62 85.3,26.75 85.3,27.67 85.43,27.8 85.81,27.8 85.94,27.67 85.94,26.73 86.07,26.6 86.37,26.6 86.5,26.73 86.5,27.05 86.62,27.18 86.98,27.18 87.11,27.05 87.11,26.73 87.23,26.6 89.08,26.6 92.39,23.29 92.39,22.34 v2(92.56,22.17)
M_B_DQ62: length 38.9
  IN4 w0.152: v2(96.56,21.37) 95.79,21.37 94.58,22.58 94.58,23.87 88.67,29.77 85.07,29.77 81.48,33.36 77.7,33.36 75.52,35.54 75.52,37.16 75.3,37.39 74.97,37.39 69.99,42.37 68.32,42.37 v2(68.17,42.22)
M_B_DQ63: length 39.8
  IN4 w0.152: v2(68.17,42.85) 68.34,42.68 70.14,42.68 74.91,37.9 76.26,37.9 76.82,37.34 76.82,35.23 78.31,33.74 81.64,33.74 85.23,30.15 88.93,30.15 94.96,24.13 94.96,22.74 95.64,22.06 96.28,22.06 96.45,22.23 96.45,22.87 v2(96.56,22.97)
M_B_DQSN0: length 30.6
  IN3 w0.089: 59.28,37.64 59.29,37.65 59.29,37.71 59.7,38.12 59.7,39.99 59.77,40.06 v2(59.91,40.06)
  IN3 w0.165: 59.28,37.64 59.22,37.57 59.22,35.85 58.84,35.47 58.84,30.03 59.27,29.6 59.27,26.63 58.71,26.07 58.71,25.73 59.27,25.18 59.27,24.69 59.97,23.99 59.97,23.48 59.61,23.12 58.6,23.12 58.43,22.94 58.43,22.61 58.59,22.45 59,22.45 59.36,22.09 59.36,21.58 59,21.23 58.59,21.23 58.42,21.05 58.42,20.68 58.61,20.49 60.03,20.49 60.42,20.1 61.47,20.1 61.76,19.8 62.3,19.8 62.77,19.33 62.77,18.78 62.54,18.55 62.37,18.55 62.27,18.44 v2(62.27,18.31)
  BOTTOM w0.216: v2(62.27,18.31) 62.27,18.42 62.34,18.5 62.7,18.5 U22.G3
M_B_DQSN1: length 32.1
  IN4 w0.089: 61.57,38.6 61.94,38.97 61.94,39.81 62.05,39.92 62.05,40.42 v2(62.35,40.71)
  IN4 w0.165: 61.57,38.6 60.86,37.89 60.33,37.89 59.23,36.8 58.98,36.8 58.5,36.32 58.5,35.62 58.9,35.22 59.26,35.22 59.48,35 59.48,30.39 59.9,29.98 59.9,26.25 60.19,25.96 60.76,25.96 60.96,25.76 60.96,25.48 60.76,25.28 58.88,25.28 58.6,24.99 58.6,24.32 58.88,24.03 61.71,24.03 61.84,23.91 61.84,23.49 61.71,23.36 61.09,23.36 60.73,23 60.73,22.5 61.09,22.14 61.71,22.14 61.84,22.01 61.84,21.42 61.68,21.26 61.07,21.26 60.42,21.91 60.09,21.91 v2(59.83,22.17)
M_B_DQSN2: length 33.2
  IN3 w0.089: 62.61,38.56 62.61,40.73 61.22,42.12 61.22,43.62 61.32,43.72 61.38,43.72 v2(61.61,43.5)
  IN3 w0.165: v2(73.44,17.99) 73.61,18.17 73.87,18.17 74.12,18.42 74.12,18.9 73.67,19.36 73.08,19.36 64.14,28.3 64.14,32.41 63.43,33.13 63.43,36.08 62.61,36.89 62.61,38.56
  BOTTOM w0.216: v2(73.44,17.99) 73.73,18.28 74.09,18.28 U23.G3
M_B_DQSN3: length 31.7
  IN4 w0.089: v2(63.51,43.5) 63.3,43.5 63.23,43.57 63.23,43.74 63.31,43.82 63.61,43.82 63.81,43.62 63.81,43.41 63.64,43.24 63.31,43.24 63.05,42.98 63.05,42.02 63.31,41.76 63.49,41.76 63.54,41.71 64.09,41.71 64.63,41.17 64.63,38.48 64.59,38.43
  IN4 w0.165: v2(71,22.17) 71.42,21.76 71.65,21.76 71.88,21.53 71.88,20.8 72.08,20.6 72.36,20.6 72.57,20.8 72.57,22.25 72.21,22.6 72.21,24.24 64.49,31.96 64.49,36.31 64.59,36.41 64.59,38.43 64.59,38.43
M_B_DQSN4: length 32.2
  IN3 w0.089: v2(65.07,40.06) 65.16,39.97 65.16,38.92 65.37,38.71 65.37,38.65 65.39,38.63
  IN3 w0.165: v2(85.38,18.17) 85.38,18.52 85.2,18.7 84.08,18.7 82.53,20.25 81.6,20.25 70.7,31.15 70.03,31.15 69.43,31.75 69.43,32.41 67.51,34.34 67.51,37.05 66.25,38.31 65.71,38.31 65.39,38.63
M_B_DQSN5: length 29.3
  IN4 w0.089: v2(67.48,40.71) 67.85,40.34 67.85,38.99 68.43,38.42 68.47,38.42
  IN4 w0.165: v2(82.94,21.84) 82.94,21.82 82.77,21.65 82.58,21.65 82.43,21.8 82.43,22.2 82.92,22.69 82.92,23.42 77.99,28.34 75.88,28.34 74.95,29.27 74.95,29.63 73.49,31.09 71.76,31.09 68.87,33.99 68.87,38.01 68.47,38.42
  BOTTOM w0.216: v2(82.94,21.84) 82.92,21.82 82.53,21.82 U24.B7
M_B_DQSN6: length 45.8
  IN3 w0.089: 67.27,42.18 67.25,42.18 67.2,42.14 66.73,42.14 66.53,41.94 66.15,41.94 65.95,42.14 65.95,43.59 66.06,43.71 66.11,43.71 66.26,43.56 v2(66.26,43.5)
  IN3 w0.165: v2(95.79,17.92) 95.98,18.1 96.11,18.1 96.48,18.47 96.48,19 95.72,19.76 94.48,19.76 93,21.23 91.1,21.23 84.77,27.56 84.19,27.56 79.79,31.95 78.91,31.95 78.48,32.38 78.48,33.06 77.94,33.61 77.25,33.61 76.9,33.96 76.9,34.73 76.36,35.26 75.6,35.26 74.48,36.38 74.48,36.87 69.17,42.18 67.27,42.18
  BOTTOM w0.216: U25.G3 96.44,18.29 96.16,18.29 v2(95.79,17.92)
M_B_DQSN7: length 41.4
  IN4 w0.089: v2(68.17,43.5) 68.17,43.61 68.09,43.68 67.97,43.68 67.9,43.62 67.9,42.09 68.03,41.96 69.67,41.96 69.71,42.01 69.73,42.01
  IN4 w0.165: 69.73,42.01 69.98,42.01 74.94,37.04 74.94,35.21 77.28,32.87 81.31,32.87 84.9,29.29 88.5,29.29 94.12,23.68 94.12,22.66 93.66,22.2 93.66,21.72 93.91,21.47 94.27,21.47 94.37,21.57 94.37,21.72 94.17,21.92 v2(94.12,21.92)
  BOTTOM w0.216: U25.B7 93.74,21.79 93.98,21.79 v2(94.12,21.92)
M_B_DQSP0: length 30.5
  IN3 w0.089: v2(59.91,40.71) 59.91,40.45 59.52,40.06 59.52,38.19 59.17,37.84 59.11,37.84 59.09,37.82
  IN3 w0.165: 59.09,37.82 58.95,37.68 58.95,35.96 58.57,35.58 58.57,29.92 59,29.49 59,26.74 58.44,26.18 58.44,25.62 59,25.07 59,24.58 59.71,23.88 59.71,23.59 59.5,23.39 58.49,23.39 58.16,23.05 58.16,22.5 58.48,22.18 58.89,22.18 59.09,21.98 59.09,21.69 58.89,21.49 58.48,21.49 58.15,21.16 58.15,20.57 58.5,20.22 59.92,20.22 60.31,19.83 61.35,19.83 61.65,19.54 62.19,19.54 62.51,19.22 62.51,18.89 62.43,18.81 62.3,18.81 v2(62.27,18.85)
  BOTTOM w0.216: v2(62.27,18.85) 62.29,18.83 62.88,18.83 U22.F3
M_B_DQSP1: length 31.8
  IN4 w0.089: 61.81,38.46 61.81,38.47 61.81,38.54 61.83,38.56 61.83,38.61 62.11,38.89 62.11,39.73 62.23,39.85 62.23,39.95 62.34,40.06 v2(62.35,40.06)
  IN4 w0.165: 61.81,38.46 60.97,37.62 60.44,37.62 59.34,36.53 59.09,36.53 58.77,36.21 58.77,35.73 59.01,35.49 59.37,35.49 59.75,35.11 59.75,30.5 60.16,30.09 60.16,26.36 60.3,26.23 60.87,26.23 61.23,25.87 61.23,25.37 60.87,25.01 58.99,25.01 58.86,24.88 58.86,24.43 58.99,24.3 61.82,24.3 62.11,24.02 62.11,23.38 61.82,23.09 61.2,23.09 61,22.89 61,22.61 61.2,22.41 61.82,22.41 62.11,22.12 62.11,21.31 61.8,21 60.96,21 60.31,21.65 60.1,21.65 v2(59.83,21.37)
M_B_DQSP2: length 33.1
  IN3 w0.089: v2(61.61,44.15) 61.35,43.9 61.25,43.9 61.05,43.69 61.05,42.04 62.43,40.66 62.43,38.69 62.39,38.65 62.39,38.62 62.34,38.57 62.34,38.56
  IN3 w0.165: 62.34,38.56 62.34,36.78 63.16,35.96 63.16,33.02 63.88,32.3 63.88,28.19 72.97,19.09 73.56,19.09 73.86,18.79 73.86,18.53 73.76,18.43 73.65,18.43 v2(73.44,18.64)
  BOTTOM w0.216: v2(73.44,18.64) 73.47,18.61 73.84,18.61 U23.F3
M_B_DQSP3: length 31.6
  IN4 w0.089: v2(63.51,44.15) 63.51,44.1 63.61,44 63.69,44 63.99,43.69 63.99,43.34 63.71,43.06 63.38,43.06 63.23,42.91 63.23,42.09 63.38,41.94 63.56,41.94 63.61,41.89 64.17,41.89 64.81,41.25 64.81,38.5 64.85,38.46 64.85,38.43
  IN4 w0.165: v2(71,21.37) 71.12,21.49 71.54,21.49 71.61,21.42 71.61,20.69 71.97,20.34 72.47,20.34 72.83,20.69 72.83,22.36 72.48,22.71 72.48,24.35 64.75,32.07 64.75,36.2 64.85,36.3 64.85,38.43
M_B_DQSP4: length 32.2
  IN3 w0.089: v2(65.07,40.71) 65.07,40.46 65.34,40.19 65.34,38.99 65.5,38.83 65.56,38.83 65.57,38.83 65.57,38.81
  IN3 w0.165: 65.57,38.81 65.57,38.81 65.63,38.74 65.65,38.74 65.82,38.57 66.36,38.57 67.78,37.16 67.78,34.45 69.7,32.53 69.7,31.86 70.14,31.42 70.81,31.42 81.71,20.52 82.64,20.52 84.19,18.97 85.31,18.97 85.32,18.97 v2(85.38,18.97)
M_B_DQSP5: length 29
  IN4 w0.089: v2(67.48,40.06) 67.68,39.86 67.68,38.92 68.27,38.33 68.27,38.24
  IN4 w0.165: v2(82.94,21.22) 82.78,21.38 82.47,21.38 82.17,21.69 82.17,22.31 82.65,22.8 82.65,23.31 77.88,28.08 75.77,28.08 74.69,29.16 74.69,29.52 73.38,30.83 71.65,30.83 68.6,33.88 68.6,37.9 68.27,38.24
  BOTTOM w0.216: U24.C7 82.3,21.49 82.67,21.49 v2(82.94,21.22)
M_B_DQSP6: length 45.7
  IN3 w0.089: v2(66.26,44.15) 66.26,44.05 66.13,43.91 66.01,43.91 65.77,43.67 65.77,42.07 66.08,41.76 66.61,41.76 66.81,41.96 67.2,41.96 67.25,41.91 67.27,41.91
  IN3 w0.165: 67.27,41.91 69.06,41.91 74.22,36.76 74.22,36.27 75.49,34.99 76.25,34.99 76.63,34.62 76.63,33.85 77.14,33.34 77.83,33.34 78.22,32.95 78.22,32.27 78.8,31.68 79.68,31.68 84.08,27.29 84.66,27.29 90.99,20.97 92.89,20.97 94.37,19.49 95.61,19.49 96.21,18.89 96.21,18.58 96,18.37 95.92,18.37 95.79,18.5 v2(95.79,18.72)
  BOTTOM w0.216: U25.F3 96.2,18.62 95.89,18.62 v2(95.79,18.72)
M_B_DQSP7: length 41.2
  IN4 w0.089: 69.73,41.74 69.71,41.74 69.67,41.78 67.96,41.78 67.73,42.02 67.73,43.69 67.89,43.86 67.92,43.86 68.17,44.11 v2(68.17,44.15)
  IN4 w0.165: v2(94.12,21.12) 94.03,21.2 93.8,21.2 93.39,21.61 93.39,22.31 93.85,22.77 93.85,23.57 88.39,29.02 84.79,29.02 81.2,32.61 77.17,32.61 74.67,35.1 74.67,36.93 69.87,41.74 69.73,41.74
  BOTTOM w0.216: v2(94.12,21.12) 93.78,21.45 93.44,21.45 U25.C7
M_B_ODT: length 66.6
  TOP w0.076: R247.1 61.99,13.54 v6(61.76,13.77)
  IN1 w0.089: v6(72.53,8.74) 72.69,8.74 72.79,8.63 72.79,8.19 72.2,7.6 69.68,7.6 66.28,11 64.53,11 v6(61.76,13.77) ; v6(84.59,14.53) 84.82,14.3 88.27,14.3 89.62,12.96 91.3,12.96 93.71,15.37 v6(97.75,15.37)
  IN4 w0.089: v6(72.53,8.74) 73.02,9.22 76.4,9.22 81.71,14.53 v6(84.59,14.53)
  BOTTOM w0.076: v6(97.75,15.37) 98.15,15.77 U25.K1 U25.J1 ; v6(61.76,13.77) 62.54,14.55 63.98,14.55 64.21,14.78 64.21,15.13 64.63,15.55 U22.K1 U22.J1 ; v6(72.53,8.74) 72.53,8.89 73.47,9.83 75.55,9.83 76.82,11.11 76.82,15.12 76.17,15.77 U23.K1 U23.J1 ; U24.J1 U24.K1 86.95,15.77 86.58,15.4 85,15.4 84.54,14.94 84.54,14.58 v6(84.59,14.53)
M_B_RAS#: length 131.5
  TOP w0.089: v9(81.19,17.53) 81.25,17.59 82.27,17.59 82.64,17.23 R456.2
  IN1 w0.165: v9(81.19,17.53) 82.05,18.39 82.05,21.35 79.23,24.17 79.23,24.44 80.21,25.42 80.21,25.6 79.95,25.86 79.77,25.86 78.74,24.84 78.56,24.84 78.32,25.08 78.32,25.26 79.36,26.3 79.36,26.45 78.61,27.2 77.31,27.2 74.58,29.93 70.35,29.93 67.6,32.68 67.6,33.53 67.47,33.66 66.71,33.66 66.58,33.79 66.58,34.12 66.71,34.24 67.47,34.24 67.6,34.37 67.6,34.68 67.47,34.8 66.71,34.8 66.58,34.93 66.58,35.21 66.71,35.34 67.47,35.34 67.6,35.46 67.6,35.77 67.47,35.89 66.71,35.89 66.58,36.02 66.58,36.33 66.71,36.45 67.47,36.45 67.6,36.58 67.6,36.86 67.45,37.01 66.15,37.01 65.94,37.23 65.94,37.44 66.46,37.96 66.46,38.15 66.33,38.29 66.11,38.29 65.54,37.71 65.37,37.71 65.24,37.85 65.24,38.06 65.81,38.64 65.81,38.8 65.68,38.93 65.46,38.93 64.89,38.36 64.73,38.36 64.59,38.49 64.59,38.71 65.17,39.28 65.17,39.45 65.03,39.58 64.84,39.58 64.27,39.01 64.08,39.01 63.95,39.14 63.95,39.36 64.52,39.93 64.52,40.09 64.39,40.23 64.2,40.23 63.65,39.68 63.48,39.68 63.35,39.81 63.35,40.03 63.87,40.55 63.87,40.74 63.74,40.87 63.57,40.87 62.95,40.25 62.79,40.25 62.65,40.38 62.65,40.6 63.23,41.17 63.23,41.39 63.09,41.52 62.9,41.52 62.28,40.9 62.11,40.9 61.98,41.03 61.98,41.25 62.58,41.84 62.58,42.03 62.45,42.17 62.26,42.17 61.63,41.54 61.47,41.54 61.33,41.68 61.33,41.89 61.93,42.49 61.93,42.68 61.8,42.81 61.61,42.81 61.06,42.27 60.9,42.27 60.3,42.86 58.65,42.86 57.66,43.85 v5(57.61,43.85)
  IN2 w0.076: v5(90.51,18.01) 90.51,18.22 90.36,18.37 90,18.37 89.88,18.5 89.88,18.75 90,18.88 90.3,18.88 90.41,18.99 90.41,19.15 90.3,19.26 89.58,19.26 89.47,19.15 89.47,18.17 89.37,18.06 89.14,18.06 89.04,18.17 89.04,18.65 88.93,18.75 88.79,18.75 88.68,18.65 88.68,17.91 88.36,17.59 87.77,17.59 87.72,17.54 87.28,17.54 87.11,17.71 81.37,17.71 v9(81.19,17.53) 80.02,17.53 79.85,17.37 79.33,17.37 79.21,17.49 79.21,17.84 79.11,17.94 69.69,17.94 69.46,18.17 69.31,18.17 69.23,18.09 69.23,18.01 69.16,17.94 69.01,17.94 68.93,18.01 68.93,18.09 68.85,18.17 68.31,18.17 v5(68.16,18.01)
  IN4 w0.076: v2(85.38,16.55) 85.28,16.55 84.71,15.97 84.55,15.97 84.24,16.29 84.24,16.41 84.9,17.07 84.9,17.36 85.2,17.66 86.88,17.66 87.02,17.52 88.36,17.52 88.66,17.81 89.39,17.81 89.6,18.01 v5(90.51,18.01) 92.44,18.01 92.97,17.48 92.97,17.17 93.58,16.57 95.25,16.57 95.34,16.66 95.34,17.12 95.42,17.2 95.57,17.2 95.65,17.12 95.65,16.74 95.73,16.66 95.88,16.66 95.95,16.74 95.95,17.2 96.03,17.28 96.18,17.28 96.26,17.2 96.26,16.87 v2(96.56,16.57) ; v2(63.03,16.55) 62.93,16.55 62.36,15.97 62.2,15.97 61.88,16.29 61.88,16.41 62.54,17.07 62.54,17.36 62.85,17.66 64.53,17.66 64.67,17.52 66.01,17.52 66.3,17.81 66.94,17.81 67.14,18.01 v5(68.16,18.01) 70.09,18.01 70.62,17.48 70.62,17.17 71.23,16.57 72.9,16.57 72.99,16.66 72.99,17.12 73.07,17.2 73.22,17.2 73.3,17.12 73.3,16.74 73.37,16.66 73.53,16.66 73.6,16.74 73.6,17.2 73.68,17.28 73.83,17.28 73.91,17.2 73.91,16.87 v2(74.2,16.57)
  IN4 w0.165: v2(57.29,44.15) 57.31,44.15 v5(57.61,43.85)
M_B_WE#: length 125.3
  TOP w0.089: v9(81.77,15.37) 82.59,14.56 R446.2
  IN1 w0.165: v5(57.61,45.16) 57.79,45.34 58.1,45.34 58.23,45.22 58.23,43.69 58.51,43.41 58.91,43.41 59.16,43.17 61.9,43.17 62.81,42.26 63,42.26 63.41,42.67 63.6,42.67 63.73,42.53 63.73,42.34 63.32,41.93 63.32,41.74 63.46,41.61 63.65,41.61 64.05,42.02 64.24,42.02 64.38,41.88 64.38,41.7 63.97,41.29 63.97,41.1 64.1,40.96 64.29,40.96 64.7,41.37 64.89,41.37 65.02,41.24 65.02,41.05 64.62,40.64 64.62,40.45 64.75,40.32 64.94,40.32 65.35,40.73 65.54,40.73 65.67,40.59 65.67,40.4 65.26,39.99 65.26,39.8 65.4,39.67 65.59,39.67 65.99,40.08 66.18,40.08 66.32,39.94 66.32,39.76 66.02,39.46 66.02,39.18 66.64,38.55 67.65,38.55 67.78,38.43 67.78,38.16 67.65,38.03 67.09,38.03 66.96,37.9 66.96,37.6 67.09,37.47 67.84,37.47 67.97,37.34 67.97,32.98 70.64,30.31 74.72,30.31 76.81,28.22 78.11,28.22 80.66,25.67 80.66,25.35 79.77,24.46 79.77,24.15 81.43,22.49 82.46,21.46 82.46,20.81 82.59,20.68 83.96,20.68 84.08,20.55 84.08,20.25 83.96,20.12 82.59,20.12 82.46,19.99 82.46,19.69 82.59,19.56 83.96,19.56 84.08,19.44 84.08,19.13 83.96,19 82.59,19 82.46,18.88 82.46,18.57 82.59,18.44 83.95,18.44 84.08,18.32 84.08,18.03 83.95,17.9 82.06,17.9 81.16,17 81.16,15.78 81.57,15.37 v9(81.77,15.37)
  IN2 w0.076: v5(68.13,15.88) 67.9,15.65 67.55,15.65 67.45,15.75 67.45,16.03 67.68,16.26 68.46,16.26 68.84,15.88 69.05,15.88 69.58,15.35 78.22,15.35 78.32,15.45 81.7,15.45 v9(81.77,15.37) 81.86,15.37 82.09,15.6 82.24,15.6 82.39,15.45 82.54,15.45 82.7,15.6 82.85,15.6 83,15.45 83.15,15.45 83.31,15.6 83.46,15.6 83.61,15.45 83.76,15.45 83.92,15.6 84.07,15.6 84.22,15.45 84.37,15.45 84.53,15.6 84.68,15.6 84.83,15.45 85.25,15.45 85.32,15.37 85.32,15.19 85.4,15.12 85.55,15.12 85.6,15.17 85.6,15.54 85.68,15.61 85.83,15.61 85.91,15.54 85.91,15.22 86.01,15.12 86.16,15.12 86.24,15.19 86.24,15.31 86.31,15.38 86.46,15.38 86.54,15.31 86.54,15.19 86.62,15.12 86.77,15.12 86.85,15.19 86.85,15.31 86.92,15.38 87.07,15.38 87.15,15.31 87.15,15.19 87.23,15.12 87.38,15.12 87.45,15.19 87.45,15.37 87.51,15.42 87.7,15.42 87.78,15.35 87.78,15.17 87.86,15.09 88.01,15.09 88.05,15.13 88.05,15.32 88.15,15.42 88.48,15.42 88.58,15.52 88.58,15.73 88.76,15.9 89.9,15.9 90.31,15.5 90.92,15.5 90.97,15.45 90.97,15.12 91.09,14.99 91.58,14.99 91.7,15.12 91.7,15.63 91.45,15.88 v5(90.48,15.88)
  IN4 w0.076: v2(63.03,14.97) 63.03,14.79 63.11,14.71 64.01,14.71 64.09,14.79 64.09,14.99 64.14,15.04 64.3,15.04 64.35,14.99 64.35,14.76 64.4,14.71 64.77,14.71 65.02,14.95 65.02,15.05 64.97,15.1 64.97,15.21 65.08,15.31 65.19,15.31 65.23,15.27 65.34,15.27 65.59,15.52 66.68,15.52 67.04,15.88 v5(68.13,15.88) 69.86,15.88 70.06,15.68 72.78,15.68 73.57,14.89 74.12,14.89 v2(74.2,14.97) ; v2(85.38,14.97) 85.38,14.79 85.46,14.71 86.36,14.71 86.45,14.79 86.45,14.99 86.5,15.04 86.65,15.04 86.7,14.99 86.7,14.76 86.75,14.71 87.13,14.71 87.37,14.95 87.37,15.05 87.32,15.1 87.32,15.21 87.43,15.31 87.54,15.31 87.58,15.27 87.69,15.27 87.94,15.52 89.04,15.52 89.39,15.88 v5(90.48,15.88) 92.21,15.88 92.42,15.68 95.13,15.68 95.92,14.89 96.47,14.89 v2(96.56,14.97)
  IN4 w0.165: v5(57.61,45.16) 57.32,45.45 v2(57.29,45.45)
MCP_RSVD_19: length 8.4
  BOTTOM w0.127: TP114.1 33.51,44.63 34.83,44.63 35.21,44.25 35.54,44.25 39.39,40.41 U16.AV63
MCP_RSVD_20: length 6.8
  BOTTOM w0.127: U16.AU63 39.26,41.04 35.8,44.51 35.34,44.51 34.68,45.17 TP115.1
MCP_RSVD_21: length 9.6
  BOTTOM w0.127: TP67.1 31.25,60.3 32.06,60.3 32.37,60 34.83,60 35.23,60.4 U16.C63
MCP_RSVD_22: length 7.3
  BOTTOM w0.089: U16.C62 39.81,60.33 39.56,60.07 39.05,60.07 39,60.02
  BOTTOM w0.127: 39,60.02 38.69,60.02 38.57,60.14 35.36,60.14 34.96,59.75 33.51,59.75 TP68.1
MCP_RSVD_23: length 6.7
  BOTTOM w0.127: U16.B43 52.59,61.51 52.59,62.41 52.21,62.79 52.21,63.83 52.59,64.22 52.59,66.88 TP49.1
MCP_RSVD_24: length 3.2
  BOTTOM w0.127: U16.A51 47.13,64.29 47.3,64.46 TP59.1
MCP_RSVD_25: length 5.5
  BOTTOM w0.127: U16.B51 46.82,61.37 46.82,61.52 46.67,61.68 46.67,64.5 46.78,64.61 46.78,65.24 47.3,65.77 TP54.1
MCP_RSVD_26: length 4.8
  TOP w0.127: TP12.1 38.29,54.97 38.78,54.97 39.07,54.68 39.57,54.68 v4(39.58,54.69)
  IN1 w0.089: v4(39.58,54.69) 39.84,54.94 41.18,54.94 v5(41.41,54.72)
  IN4 w0.089: v2(41.67,54.99) 41.67,54.97 v5(41.41,54.72)
  BOTTOM w0.127: U16.L60 41.41,55.24 v2(41.67,54.99)
MCP_RSVD_69: length 11.7
  TOP w0.127: TP20.1 32.95,50.88 v4(33.11,50.73)
  IN1 w0.089: v5(33.23,50.12) 33.23,50.6 v4(33.11,50.73)
  IN3 w0.089: v2(41.64,53.34) 40.52,53.34 39.38,52.2 35.19,52.2 34.38,51.39 34.38,51.26 v5(33.23,50.12)
  BOTTOM w0.127: U16.P60 41.64,53.44 v2(41.64,53.34)
MCP_RSVD_70: length 6
  TOP w0.127: v4(39.08,53.42) 38.82,53.67 37.04,53.67 TP14.1
  IN1 w0.089: v4(39.08,53.42) 39.18,53.32 39.81,53.32 v5(40.45,52.68)
  IN4 w0.089: v2(41.01,52.79) 40.9,52.68 v5(40.45,52.68)
  BOTTOM w0.127: v2(41.01,52.79) 41.01,53.42 40.69,53.74 U16.P61
MCP_RSVD_71: length 10.9
  TOP w0.127: v4(33.64,51.46) 34.17,51.46 TP18.1
  IN1 w0.089: v5(33.64,51.06) v4(33.64,51.46)
  IN3 w0.089: v2(41.99,54.57) 41.22,53.8 40.47,53.8 39.21,52.54 35.02,52.54 33.64,51.16 v5(33.64,51.06)
MCP_RSVD_72: length 5.6
  TOP w0.127: TP11.1 37.42,54.56 38.8,54.56 v4(39.04,54.32)
  IN1 w0.089: v5(38.66,54.32) v4(39.04,54.32)
  IN4 w0.089: v5(38.66,54.32) 38.66,54.27 v2(38.97,53.95)
  BOTTOM w0.127: U16.N61 40.25,54.13 39.15,54.13 v2(38.97,53.95)
ME_SUS_PWR_ACK: length 80.7
  TOP w0.127: v9(140.14,57.55) 140.14,57.34 U4.G12 ; v7(78.22,39.93) 77.94,40.21 R145.1 v4(77.94,40.97)
  IN1 w0.089: v9(124.29,53.97) 123.62,53.97 121.21,51.55 117.07,51.55 116.3,50.79 112.26,50.79 111.81,50.34 103.78,50.34 102.45,49 97.24,49 96.58,49.66 95.15,49.66 91.7,46.21 91.7,45.04 91.93,44.81 91.93,44.23 91.12,43.41 91.12,43.31 87.97,40.16 87.97,39.37 87.39,38.79 86.47,38.79 85.45,37.77 81.14,37.77 v4(77.94,40.97)
  IN2 w0.089: v9(140.14,57.55) 140.14,57.41 139.86,57.13 138.52,57.13 138.32,56.93 137.4,56.93 137.17,56.7 137.17,56.13 137.06,56.01 137.06,53.66 136.79,53.4 136.79,52.81 136.43,52.46 134.96,52.46 134.48,51.97 133.92,51.97 133.49,51.54 132.24,51.54 131.99,51.29 129.22,51.29 126.27,54.23 124.55,54.23 v9(124.29,53.97)
ME_SUS_PWR_ACK_R: length 22.8
  TOP w0.127: R145.2 R144.1 77.43,41.24 77.43,40.42 v7(76.95,39.93) 76.57,39.93 76.18,40.33 v4(76.04,40.33)
  IN1 w0.089: v4(76.04,40.33) 76.04,40.33 v5(75.68,40.7) ; v9(83.9,44.28) 87.15,47.52 v5(88.12,47.52)
  IN2 w0.089: v5(75.68,40.7) 76.13,40.7 76.51,41.08 77.35,41.08 77.65,41.37 79.81,41.37 82.71,44.28 v9(83.9,44.28)
  IN3 w0.089: v5(88.12,47.52) 87.26,47.52 87.21,47.58 v2(86.01,47.58)
  IN4 w0.089: v2(76.04,40.41) 75.97,40.41 v5(75.68,40.7)
  BOTTOM w0.127: R319.1 v2(86.01,47.58)
MODPHY_EN: length 49.9
  TOP w0.127: PR48.1 105.42,43.54 v4(105.01,43.13) ; v4(89.11,52.13) 89.14,52.1 v7(89.77,52.1) 90.13,52.46 90.13,53.01 90.54,53.42 92.03,53.42 D10.2
  IN1 w0.089: v5(105.41,43.09) 105.06,43.09 v4(105.01,43.13) ; v4(89.11,52.13) 89.1,52.11 87.15,52.11 87.08,52.18 82.2,52.18 v5(81.72,52.66)
  IN2 w0.089: v5(95.23,47.45) 93.69,49 89.44,49 88.96,49.48 83.25,49.48 81.72,51.01 v5(81.72,52.66)
  IN3 w0.089: v2(80.86,51.44) 80.86,51.85 81.67,52.66 v5(81.72,52.66) ; v5(95.23,47.45) 95.72,47.93 100.8,47.93 103.67,45.06 104.94,45.06 105.41,44.59 v5(105.41,43.09)
  BOTTOM w0.127: U16.Y2 77.69,50.42 78.8,50.42 79.03,50.65 80.07,50.65 v2(80.86,51.44)
MPCIE_RST_N: length 129.1
  TOP w0.127: 172.22,28.87 U14.2 ; 172.22,28.87 171.64,28.29 v4(171.64,27.84) ; 172.22,28.87 172.02,29.07 v7(172.02,29.67) 172.68,29.67 173.2,30.19 R183.2 173.2,30.7 173.57,31.07 173.57,31.96 173.91,32.3 U12.2
  IN1 w0.089: v5(171.16,28.15) 171.46,27.84 v4(171.64,27.84)
  IN3 w0.089: v8(164.78,44.1) 161.12,47.76 157.95,47.76 157.72,47.53 156.83,47.53 156.6,47.76 156.32,47.76 156.25,47.68 145.17,47.68 141.18,43.69 136.51,43.69 135.64,42.82 131.26,42.82 129.65,44.43 115.09,44.43 111.38,48.14 103.54,48.14 101.64,50.04 92.47,50.04 91.16,48.73 88.59,48.73 87.51,49.81 87.23,49.81 87.08,49.66 87.08,49.28 86.81,49.01 84.44,49.01 84.09,49.36 77.66,49.36 76.82,50.19 76.82,50.45 76.64,50.63 75.86,50.63 74.99,51.5 74.99,52.26 v2(74.73,52.52)
  IN4 w0.089: v5(171.16,28.15) 172.83,29.82 172.83,36.2 164.98,44.05 164.83,44.05 v8(164.78,44.1)
NB_MUTE#: length 216.1
  TOP w0.127: R464.1 100.92,32.54 v4(101.05,32.41) ; v9(55.35,21.97) 47.82,21.97 47.3,22.5 40.3,22.5 38.94,23.86 15.98,23.86 v7(15.58,24.26) 15.58,25.34 10.75,30.17 10.75,35.49 13.03,37.76 17.88,37.76 20.41,35.23 v6(20.41,35.01)
  IN1 w0.089: v9(133.92,42.3) 134.05,42.17 134.05,35.23 133.64,34.83 133.36,34.83 133.21,34.98 132.5,34.98 132.32,34.8 132.32,34.57 132.85,34.04 132.85,33.18 132.49,32.82 130.06,32.82 127.49,35.39 116.57,35.39 116.11,34.93 116.11,32.57 115.25,31.7 112.84,31.7 112.1,30.97 105.55,30.97 104.61,30.03 104.61,29.09 104.48,28.96 104.48,26.32 102.35,24.19 100.09,24.19 99.53,23.63 97.99,23.63 v9(97.65,23.97) 97.47,24.15 97.47,25.33 99.43,27.28 99.43,30.6 101.05,32.22 v4(101.05,32.41) ; v9(145.25,44.23) 145.09,44.38 145.09,51.54 145.74,52.18 145.74,55.33 146.31,55.9 146.31,58.23 144.72,59.83 144.58,59.96 142.06,59.96 141.84,59.75 140.77,59.75 140.51,59.48 v4(140.51,59.49)
  IN2 w0.089: v9(97.65,23.97) 97.4,23.73 82.41,23.73 78.08,28.06 76.12,28.06 71.69,23.63 60.07,23.63 57.74,21.29 56.03,21.29 v9(55.35,21.97) ; v9(145.25,44.23) 145.02,44.23 142.68,41.89 140.83,41.89 140.24,41.3 138.72,41.3 137.64,42.38 134,42.38 v9(133.92,42.3)
  BOTTOM w0.127: CN3.48 19.9,35.51 v6(20.41,35.01)
Net_2: length 0.5
  BOTTOM w0.127: v2(69.48,59.47) 69.7,59.25 69.7,59.1
NGFF_PCIE_WLAN_WAKE_R#: length 27
  TOP w0.127: 168.92,25.94 168.95,25.96 168.95,28.15 ; 168.92,25.94 169.33,25.53 169.33,24.97 169.8,24.5 170.52,23.78 v6(171.05,23.78) ; 168.92,25.94 168.84,25.86 Q43.2 ; 168.95,28.15 169.07,28.27 169.07,30.11 R193.2 168.88,31.05 R187.2 ; 168.95,28.15 Q44.2
  IN1 w0.089: v5(181.09,23.14) 182.03,24.08 v4(182.7,24.08)
  IN3 w0.089: v5(181.09,23.14) 179.11,23.14 177.38,21.42 174.71,21.42 172.35,23.78 v6(171.05,23.78)
  BOTTOM w0.127: CN4.55 171.17,23.9 v6(171.05,23.78)
NGFF_SATA_SSD_PWREN: length 118.8
  TOP w0.127: R37.2 85.18,60.15 85.28,60.15 85.99,60.86 86.02,60.88 86.52,61.38 86.54,61.41 87.34,62.21 87.34,63.83 88.94,65.43 92.82,65.43 94.27,66.88 102.7,66.88 104.4,65.18 110.14,65.18 111.67,66.7 114.44,66.7 115.48,65.66 123.4,65.66 125.46,67.72 141.87,67.72 142.42,67.17 147.71,67.17 150.64,64.24 v7(151.39,64.24) 154.04,64.24 156.35,61.93 157.69,61.93 158.2,62.44 160.23,62.44 160.61,62.06 160.61,59.69 161.15,59.16 161.15,57.56 158.53,54.94 158.53,49.94 v4(158.1,49.51)
  IN1 w0.089: v4(164.91,33.85) 165.3,33.85 165.62,34.17 165.62,36.99 160.74,41.86 160.74,46.87 v4(158.1,49.51)
NGFF_WLAN_PCIE_RST#: length 7.6
  TOP w0.127: v6(178.73,26.96) 177.99,27.7 R487.2 177.98,27.97 R191.1 176.35,27.97 176.1,28.22 U14.4
  BOTTOM w0.127: v6(178.73,26.96) 178.73,25.44 179.52,24.65 CN4.52
NGFF_WLAN_PWR_EN: length 93.2
  TOP w0.127: D25.1 165.67,45.6 v4(164.91,46.36) ; v4(94.7,46.05) 94.19,45.55 92.67,45.55 91.98,46.23 v7(91.73,46.23) 91.35,46.61 89.9,46.61 89.81,46.7 88.57,46.7 87.5,47.77 84.37,47.77 R114.1 82.14,47.32 R118.1
  IN1 w0.089: v5(115.15,48.68) 114.63,49.2 113.26,49.2 112.87,48.82 105.12,48.82 103.73,47.43 99.06,47.43 98.92,47.58 96.73,47.58 96.11,46.96 95.48,46.96 94.7,46.18 v4(94.7,46.05) ; v5(164.5,46.54) 164.73,46.54 v4(164.91,46.36)
  IN3 w0.089: v5(164.5,46.54) 164.5,47.65 162.53,49.62 158.37,49.62 157.92,50.07 148.55,50.07 148.32,49.84 142.76,49.84 141.61,48.7 134.66,48.7 133.89,47.93 132.78,47.93 131.12,49.59 120.79,49.59 119.01,47.81 115.99,47.81 115.15,48.65 v5(115.15,48.68)
NGFF_WLAN_PWR_EN_EC: length 43.9
  TOP w0.127: D25.2 166.99,47.68 164.55,50.12 v7(164.55,53.9) v4(164.55,56.09) ; U4.B7 v4(138.11,59.48)
  IN1 w0.089: v9(157.41,58.07) 158.89,56.6 164.04,56.6 v4(164.55,56.09) ; v9(139.3,62.59) 139.3,62.29 138.95,61.93 138.95,61.34 138.26,60.65 138.26,59.63 v4(138.11,59.48)
  IN2 w0.089: v9(139.3,62.59) 139.63,62.59 139.96,62.26 146.59,62.26 147.23,61.62 147.23,60.69 149.77,58.15 157.34,58.15 v9(157.41,58.07)
NGFF_WLAN_PWR_EN_R: length 3.8
  TOP w0.127: PU9.5 166.71,35.9 v6(167.19,35.41) 167.97,34.63 PR96.1 PR232.1
NGFF_WLAN_SDIO_RST#: length 5.6
  TOP w0.127: v6(170.85,33.36) 171.36,33.87 R170.2 172.52,33.38 U12.4
  BOTTOM w0.127: CN4.23 171.78,31.9 171.36,32.32 v7(171.36,32.41) 171.36,32.85 v6(170.85,33.36)
NOA_RCOMP: length 4.6
  IN3 w0.089: v2(35.52,51.29) 39.14,51.29 v2(39.39,51.54)
  BOTTOM w0.127: R298.2 35.25,51.29 v2(35.52,51.29)
OZ9955H_CMP: length 4.5
  TOP w0.127: v7(180.81,57.89) 181.25,58.33 PC4.1
  TOP w0.203: PR18.1 182.54,58.55 182.32,58.33 PC4.1 181.62,58.41 PU1.22
OZ9955H_DIM: length 8.7
  TOP w0.203: PU1.6 184.22,63.69 184.36,63.83 184.36,64.06 185.4,65.1 185.4,65.79 185.99,66.37 v7(186.98,66.37) 187.21,66.15 187.58,66.15 187.59,66.16 PC1.1 PR6.1 PR7.2
OZ9955H_ENA: length 7.9
  TOP w0.203: PU1.1 184.19,61.19 184.2,61.19 v6(185.1,61.19)
  BOTTOM w0.127: PR164.2 v7(190.33,60.13)
  BOTTOM w0.203: PR164.2 PR163.2 PR162.2 PR161.1 PC147.1 185.13,61.16 v6(185.1,61.19)
OZ9955H_FSET: length 5.7
  TOP w0.127: PR16.1 186.32,61.23 187.66,61.23 v7(187.67,61.22)
  TOP w0.203: PU1.2 185.04,61.69 185.3,61.96 PR14.2 185.93,61.26 185.88,61.21 PR16.1
OZ9955H_IFB1: length 3.6
  TOP w0.203: PR5.1 184.74,65.46 v6(184.57,65.28) 182.79,65.28 182.62,65.1 PU1.7
OZ9955H_IFB2: length 2.7
  TOP w0.203: PU1.8 182.12,65.13 182.88,65.89 v6(182.92,65.89) 183.38,65.89 PR4.1
OZ9955H_IFB3: length 1.9
  TOP w0.203: PU1.9 181.62,65.18 182.08,65.64 PR3.1
OZ9955H_IFB4: length 1.7
  TOP w0.203: PU1.10 181.12,65.49 181.06,65.54 PR2.1
OZ9955H_IFB5: length 2.4
  TOP w0.203: PR225.1 179.68,65.33 179.89,65.33 180.12,65.11 PU1.12
OZ9955H_IFB6: length 3.7
  TOP w0.203: PR223.1 178.32,65.67 v6(178.32,65.28) 178.55,65.05 178.55,63.83 178.69,63.69 PU1.13
OZ9955H_IFB7: length 3.4
  TOP w0.203: PU1.14 178.41,63.19 178.06,63.53 v6(178.06,64.01) 178.06,64.61 PR221.1
OZ9955H_IFB8: length 3.1
  TOP w0.203: PR224.1 177.6,63.8 177.6,63.2 v6(178.06,62.74) 178.12,62.69 PU1.15
OZ9955H_ISET: length 2
  TOP w0.203: PU1.11 180.62,65.21 179.79,66.03 PR1.1
OZ9955H_LCT: length 3
  TOP w0.203: PU1.3 184.66,62.19 v6(184.67,62.18) 184.85,62.18 185.32,62.66 185.32,62.99 185.43,63.1 PR12.1
OZ9955H_OVP: length 5.2
  TOP w0.127: v7(175.35,62.74) 176.62,62.74 PR13.2
  TOP w0.203: PU1.16 177.93,62.19 177.89,62.23 PR13.2 PR10.1
OZ9955H_SW:
  vias: v7(177.76,58.12) v7(179.16,58.12) v10(177.12,59.8) v10(177.66,59.06) v10(177.91,59.8) v10(178.44,59.06) v10(178.67,59.8) v10(179.26,59.06) v10(179.41,59.8)
OZ9955H_VREF: length 11.1
  TOP w0.203: PR11.1 187.41,64.27 v7(187.94,63.73) 187.97,63.71 187.97,62.46 187.46,61.96 v4(186.71,61.96) ; v4(185.9,59.64) 185.56,59.64 185.56,59.67 185.15,60.08 183.8,60.08 183.37,59.64 182.76,59.64 182.62,59.79 PU1.24
  IN1 w0.203: v4(186.71,61.96) 186.71,60.45 v4(185.9,59.64)
OZ9955H_VSCP: length 4.8
  TOP w0.203: PR9.1 PR11.2 185.46,64.27 v7(184.92,63.73) 184.95,63.71 184.95,62.97 184.66,62.69 PU1.4
PANEL_BKEN: length 156.1
  TOP w0.127: v4(142.07,56.98) 142.07,57.33 141.82,57.59 141.12,57.59 U4.F13
  IN1 w0.089: v9(190.81,56.06) 190.81,60.91 v5(189.7,62.03) ; v4(142.07,56.98) v9(144.36,56.98)
  IN2 w0.089: v5(89.72,65.51) 92.39,65.51 93.71,66.83 102.5,66.83 103.97,65.36 103.97,58.15 106.39,55.73 113.37,55.73 115.16,53.94 118.4,53.94 119.43,52.91 123.07,52.91 123.56,52.43 126.43,52.43 129.08,49.78 135.96,49.78 136.18,49.56 139.86,49.56 142.25,51.95 142.25,52.28 143.14,53.17 143.47,53.17 144.05,53.75 144.05,55.86 144.43,56.23 144.43,56.91 v9(144.36,56.98) 144.61,56.98 145.98,55.61 163.97,55.61 165.21,56.85 170.95,56.85 171.54,57.43 173.72,57.43 174.9,56.25 175.59,56.25 176.92,54.92 181.01,54.92 182.41,56.32 186.95,56.32 188.07,55.2 190.13,55.2 190.81,55.88 v9(190.81,56.06)
  IN3 w0.089: v2(77.42,63.67) 77.42,64.34 80.73,67.64 88.99,67.64 89.72,66.91 v5(89.72,65.51)
  IN4 w0.089: v5(189.7,62.03) 189.29,62.03 v2(189.19,61.93)
  BOTTOM w0.127: PR163.1 190.15,62.9 v7(190.15,62.97) ; v2(77.42,63.67) 76.21,63.67 75.97,63.43 75.32,63.43 74.33,62.44 72.95,62.44 72.56,62.05 U16.A9
PBAT_ALERT#: length 85.2
  TOP w0.127: ESD2.3 107.31,15.74 v6(106.89,15.32) 107.77,14.44 PR133.1 107.77,13.92 107.66,13.81 PR140.2 v7(108.56,13.27) ; U4.D1 133.59,58.48 132.55,59.52 132.55,59.95 132.35,60.15 130.41,60.15 v6(130.39,60.13)
  IN4 w0.089: v6(106.89,15.32) 107.88,14.33 113.75,14.33 114.11,14.69 117.94,14.69 119.01,13.62 122.51,13.62 122.69,13.8 122.69,19.23 125.44,21.97 125.44,23.52 v2(130.29,28.38)
  BOTTOM w0.127: v6(130.39,60.13) 125.66,60.13 123.43,57.89 123.43,49.09 130.29,42.23 v2(130.29,28.38)
PBAT_PRES#: length 94.2
  TOP w0.127: v4(103.13,22.97) 103.29,22.81 104.38,22.81 v7(105.88,21.32) 108.13,19.06 ESD2.1 108.79,17.64 108.93,17.51 108.93,15.29 PR134.2 110.7,13.51 PR141.2 ; U4.F10 139.75,57.72 139.79,57.72 v9(139.8,57.73)
  IN1 w0.089: v4(103.13,22.97) 102.8,23.3 99.29,23.3 98.62,22.63 97.45,22.63 96.48,23.6 96.48,29.09 97.98,30.59 97.98,33.13 98.65,33.8 99.82,33.8 100.19,34.17 102.63,34.17 105.14,36.68 105.14,37.6 104.61,38.13 104.61,39.81 104.35,40.06 104,40.06 103.59,40.47 103.59,41.41 103.74,41.56 104.4,41.56 104.84,41.99 106.61,41.99 107.99,40.62 112.05,40.62 113.75,42.32 113.75,44.33 114.23,44.81 118.93,44.81 120.56,46.44 124.32,46.44 127.29,49.41 129.27,49.41 129.75,49.89 129.75,51.36 v9(130.01,51.62)
  IN2 w0.089: v9(130.01,51.62) 130.15,51.76 131.8,51.76 131.96,51.92 133.39,51.92 133.64,52.18 134.35,52.18 134.86,52.68 136.22,52.68 136.61,53.08 136.61,53.53 136.88,53.8 136.88,56.09 136.99,56.21 136.99,56.77 137.33,57.11 138.16,57.11 138.54,57.48 139.55,57.48 v9(139.8,57.73)
PCH_EDM: length 7.6
  BOTTOM w0.089: U16.AV2 77.7,40.06 78.22,40.06 78.36,39.92
  BOTTOM w0.127: TP135.1 81.98,35.77 81.33,36.41 R353.1 81.33,37.77 79.4,39.7 78.57,39.7 78.36,39.92
PCH_GPIO80: length 6.8
  BOTTOM w0.089: U16.N2 77.47,54.39
  BOTTOM w0.127: R270.1 82.7,56.54 81.32,56.54 78.86,54.09 77.77,54.09 77.47,54.39
PCH_INTVRMEN: length 7.7
  BOTTOM w0.089: 74,37.34 74,37.8 73.43,38.37 73.43,39.96 U16.AV7
  BOTTOM w0.127: 74,37.34 74,36.71 74.38,36.33 v6(74.38,35.34) R360.1 74.75,34.38 75.01,34.13 R361.2
PCH_JTAG_TDO: length 17.5
  IN1 w0.089: v4(37.58,43.39) 37.58,44 v5(36.41,45.17)
  IN4 w0.089: v2(31.71,45.19) 32.12,45.19 32.29,45.37 36.2,45.37 v5(36.41,45.17)
  BOTTOM w0.089: U16.AE61 40.33,47.4 40.16,47.4 40.05,47.28 40.05,47.15
  BOTTOM w0.127: v2(31.71,45.19) 32.24,45.72 37.91,45.72 39.1,46.92 39.41,46.92 39.55,46.77 39.87,46.77 40.05,46.95 40.05,47.15
PCH_JTAGX: length 7.5
  TOP w0.127: R135.1 v4(41.59,43.37) R405.2
  IN1 w0.089: v4(41.59,43.37) 41.59,45.17 38.97,47.79 v5(38.69,47.79)
  IN4 w0.089: v5(38.69,47.79) v2(39.39,47.79)
PCH_MELOCK: length 118.3
  TOP w0.127: U4.A11 139.86,60.12 139.86,61.09 139.66,61.29 v4(139.53,61.29)
  IN1 w0.089: v4(139.53,61.29) 139.66,61.29 140.9,62.54 140.9,62.79 138.24,65.45 131.57,65.45 129.52,63.4 125.44,63.4 v5(124.21,62.17)
  IN2 w0.089: v5(113.12,36.1) 112.74,35.72 112.28,35.72 112.15,35.59 105.37,35.59 103.79,34.02 102.88,34.02 101.74,32.87 101.48,32.87 98.46,29.85 83.27,29.85 79.11,34.02 76.21,34.02 73.21,37.01 72.48,37.01 72.3,36.84 71.57,36.84 71.33,36.61 71.33,35.82 v5(70.78,35.26)
  IN4 w0.089: v2(70.7,34.61) 70.78,34.68 v5(70.78,35.26) ; v5(113.12,36.1) 115.33,36.1 117.69,38.46 124.57,38.46 125.16,39.04 128.45,39.04 v2(129.05,38.44) ; v2(123.92,61.82) 124.21,62.12 v5(124.21,62.17)
  BOTTOM w0.127: v2(129.05,38.44) 128.71,38.78 128.71,43.44 123.17,48.98 123.17,58.3 123.92,59.04 v2(123.92,61.82) ; R357.1 70.76,34.61 v2(70.7,34.61) 70.34,34.25 v7(70.34,33.91)
PCH_OPIICCCTL: length 1.5
  TOP w0.127: v6(67.54,47.93) 67.54,47.31 TP26.1
  BOTTOM w0.127: v6(67.54,47.93) 67.54,47.89 U16.AF20
PCH_OPIICCOBS: length 3.6
  TOP w0.127: TP25.1 66.99,47.81 66.99,49.06 v6(67.32,49.39)
  BOTTOM w0.127: U16.AB21 67.3,49.41 v6(67.32,49.39)
PCH_OPIRCOMP: length 7.3
  BOTTOM w0.102: 69,38.84 69,39.12 69.39,39.52 U16.AW15
  BOTTOM w0.305: R354.1 64.81,36.71 v7(65.11,37.01) 65.62,37.52 68.01,37.52 69,38.51 69,38.84
PCH_PWROK: length 7.6
  BOTTOM w0.089: 74.57,37.34 74.57,37.86 73.89,38.55 U16.AY7
  BOTTOM w0.127: R364.2 R363.1 77.43,34.9 v6(77,35.34) 76.26,35.34 74.57,37.03 74.57,37.34
PCH_SATA_LED#: length 13.8
  TOP w0.127: R94.1 86.37,51.96 v4(86.37,52.89) 86.73,53.24 v7(86.73,53.47)
  IN1 w0.089: v4(86.37,52.89) 86.37,52.61 v5(86.29,52.53)
  IN3 w0.089: v2(76.59,52.2) 76.72,52.07 77.18,52.07 77.61,52.51 77.61,52.71 78.34,53.45 85.58,53.45 86.29,52.73 v5(86.29,52.53)
  BOTTOM w0.127: v2(76.59,52.2) 76.6,52.21 U16.U3
PCH_SMB_ALERT#: length 20.3
  TOP w0.127: RP7.3 89.53,42.24 90.15,42.24 90.51,41.89 90.51,41.71 v4(90.64,41.58)
  IN1 w0.089: v5(89.37,39.2) 89.37,40.31 v4(90.64,41.58)
  IN4 w0.089: v5(89.37,39.2) 88.99,38.82 86.52,38.82 85.94,38.23 82.43,38.23 79.51,41.15 79.51,42.22 78.95,42.78 77.84,42.78 v2(77.36,43.25)
PCH_SPI_CLK: length 8.9
  TOP w0.127: R307.1 81.89,48.96 v4(81.87,48.98) ; v4(80.22,50.02) 79.86,50.38 EC2.2
  IN1 w0.089: v4(81.87,48.98) 81.49,49.36 81.49,49.59 81.37,49.71 80.71,49.71 80.6,49.81 80.6,50.02 80.53,50.09 80.3,50.09 v4(80.22,50.02) 80.21,50 80.21,49.7 80.12,49.61 79.94,49.61 79.87,49.69 79.87,49.92 79.82,49.97 79.56,49.97 79.44,49.84 79.44,49.64 79.33,49.53 77.45,49.53 76.72,50.27 v5(76.46,50.27)
  IN4 w0.089: v2(76.71,50.04) 76.48,50.27 v5(76.46,50.27)
PCH_SPI_CS0#: length 8.6
  TOP w0.127: v4(81.26,51.26) 81.64,51.26 R294.1
  IN1 w0.089: v4(81.26,51.26) 81.24,51.24 80.17,51.24 79.99,51.41 78.93,51.41 78.6,51.08 75.73,51.08 75.14,50.5 74.86,50.5 74.49,50.87 v5(74.34,50.87)
  IN4 w0.089: v2(74.08,50.61) v5(74.34,50.87)
PCH_SPI_IO2: length 8.2
  TOP w0.127: R304.1 81.29,51.93 v4(81.29,51.69)
  IN1 w0.089: v4(81.29,51.69) 78.93,51.69 78.52,51.29 77,51.29 76.87,51.41 75.53,51.41 v5(74.99,50.87)
  IN4 w0.089: v2(74.73,50.61) v5(74.99,50.87)
PCH_SPI_IO3: length 8.9
  IN1 w0.089: v4(83.93,48.37) 84.08,48.21 84.08,47.2 83.37,46.49 82.59,46.49 82.15,46.92 79.89,46.92 v5(79.05,47.75)
  IN4 w0.089: v2(79.41,47.76) 79.06,47.76 v5(79.05,47.75)
  BOTTOM w0.127: v2(79.41,47.76) 79.36,47.7 78.06,47.7 U16.AF1
PCH_SPI_SI: length 5.3
  IN1 w0.089: v5(77.68,49.89) 78.93,49.89 79.36,50.32 79.99,50.32 80.11,50.44 81.18,50.44 81.89,49.72 v4(81.89,49.48)
  IN4 w0.089: v5(77.68,49.89) 77.58,50 v2(77.36,50)
PCH_SPI_SO: length 7.3
  IN1 w0.089: v5(75.73,50.09) 76.29,50.65 76.84,50.65 77.25,50.25 78.78,50.25 79.21,50.68 79.82,50.68 79.97,50.83 81.56,50.83 v4(81.89,50.5)
  IN4 w0.089: v5(75.73,50.09) 76.01,50.09 v2(76.06,50.04)
