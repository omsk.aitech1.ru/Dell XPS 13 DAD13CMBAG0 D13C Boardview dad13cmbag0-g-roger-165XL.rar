# Allegro board dad13cmbag0-g-roger-165XL.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SMBDAT0: length 99.6
  TOP w0.127: RP2.1 136.16,62.64 136.28,62.52 v4(136.28,62.2) ; v4(135.51,60.39) U4.A2 ; PR87.2 126.72,36.52 126.72,36.92 126.85,37.05 v6(127,37.05) ; PR138.2 112.74,13.81 112.74,16.05 112.32,16.46 112.17,16.46 v6(111.89,16.18) 111.61,16.46 111.42,16.46 111.19,16.23 111.19,15.93 111,15.74 ESD2.4
  IN1 w0.089: v5(131.82,62.17) 132.05,62.4 132.4,62.4 133.3,63.3 135.36,63.3 136.32,62.33 136.32,62.24 v4(136.28,62.2) 136.32,62.16 136.32,60.98 135.73,60.39 v4(135.51,60.39)
  IN4 w0.089: v6(127,37.05) 126.67,36.71 126.67,36.36 126.25,35.95 123.1,35.95 119.85,32.69 117.03,32.69 115.71,34.02 113.75,34.02 112.48,32.75 112.48,31.8 111.2,30.52 105.89,30.52 105.37,30 105.37,24.85 106.74,23.47 106.74,19.66 107.53,18.88 111.95,18.88 112.76,18.06 112.76,16.84 112.44,16.53 112.23,16.53 v6(111.89,16.18) ; v2(131.3,62.23) 131.47,62.4 131.6,62.4 v5(131.82,62.17)
  BOTTOM w0.127: v2(131.3,62.23) 131.15,62.38 123.16,62.38 122.16,61.37 122.16,48.56 127.11,43.61 127.11,40.62 126.72,40.23 126.72,37.33 v6(127,37.05)
SMBDAT0_B: length 4
  TOP w0.127: v6(112.48,11.54) 112.76,11.82 112.76,11.99 PR138.1
  BOTTOM w0.127: JBAT1.B6 112.2,10.65 112.76,11.2 112.76,11.41 112.63,11.54 v6(112.48,11.54)
SMBDAT0_P: length 3.5
  TOP w0.127: PR87.1 126.6,35.15 126.6,35.01 126.74,34.88 127.72,34.88 128.19,34.41 128.19,34.02 128.25,33.96 PU12.8
SMBDAT1: length 62.3
  TOP w0.127: v4(134.46,62.3) 134.64,62.49 134.64,62.56 134.51,62.7 RP1.1 ; U4.B2 v4(135.51,59.55)
  IN1 w0.089: v5(90.26,43.64) 89.88,43.64 89.79,43.73 89.79,44.74 89.7,44.84 89.7,47.73 90.2,48.23 90.75,48.23 93.94,51.41 101.84,51.41 102.72,52.3 106.63,52.3 106.97,52.64 115.59,52.64 116.19,53.24 118.12,53.24 119.71,54.83 121.84,54.83 125.15,58.14 125.36,58.14 126.34,59.12 129.29,59.12 129.97,59.81 129.97,60.28 130.22,60.53 131.18,60.53 131.48,60.84 132.09,60.84 133.86,62.6 134.61,62.6 134.65,62.57 134.65,62.49 v4(134.46,62.3) 134.62,62.14 134.62,61.28 134.87,61.03 134.87,60.03 135.15,59.76 135.48,59.76 135.58,59.65 135.58,59.63 v4(135.51,59.55)
  IN4 w0.089: v5(90.26,43.64) v2(90.26,44.02)
  BOTTOM w0.127: Q28.6 90.27,44.04 v2(90.26,44.02)
SMBDAT3: length 93.3
  TOP w0.127: v9(143.38,52.78) 143.57,52.6 143.8,52.6 143.93,52.73 RP5.1
  IN1 w0.089: v4(178.49,21.28) 178.2,21.1 177.67,20.77 ; 177.67,20.77 177.65,20.65 177.69,20.57 178.56,20.57 178.79,20.8 180.8,20.8 180.89,20.89 v4(180.89,21.26) ; 177.67,20.77 177.55,20.8 177.51,20.87 177.38,21 177.38,29.54 176.34,30.59 176.34,40.47 176.57,40.7 176.57,42.35 176.06,42.86 176.06,43.89 177.53,45.37 177.53,46.7 v5(177.61,46.79) 177.5,46.9 177.5,47.23 176.49,48.24 176.49,55.22 175.92,55.8 175.64,55.8 v9(175.47,55.96) ; v4(138.01,58.48) 138.01,57.66 138.43,57.24 139.03,57.24 139.39,56.89 140.18,56.89 140.22,56.84 141.11,56.84 141.65,56.3 141.83,56.3 142.11,56.02 142.79,56.02 143.82,55 143.82,52.73 143.71,52.62 143.54,52.62 v9(143.38,52.78)
  IN2 w0.089: v9(143.38,52.78) 143.65,52.52 143.99,52.52 146.71,55.24 164.1,55.24 165.37,56.51 171.19,56.51 171.66,56.98 173.62,56.98 174.85,55.74 175.25,55.74 v9(175.47,55.96)
  IN4 w0.089: v2(178.39,47.37) 178.59,47.17 178.59,46.21 178.45,46.07 178.28,46.07 177.61,46.74 v5(177.61,46.79)
  BOTTOM w0.127: Q27.6 178.36,46.32 178.51,46.47 178.51,47.2 R320.2
SMBDAT3_Q: length 213.2
  TOP w0.127: v9(43.22,42.88) 43.2,42.89 42.85,42.89 42.63,42.67 42.63,39.96 39.81,37.14 32.14,37.14 27.34,41.94 26.41,41.94 v7(25.97,41.5) 25.37,42.09 20.2,42.09 19.42,41.31 19.11,41.31 19.05,41.25 U8.9 ; RP14.4 176.38,15.88 176.52,16.02 178.62,16.02 181.87,19.28 181.87,20.33 181.38,20.82 180.56,20.82 v9(180.11,21.26) 179.53,21.85 177.68,21.85 177.11,21.28 Q16.1
  IN1 w0.089: v9(99.18,31.99) 99.37,32.18 100.16,32.18 100.67,32.69 103.99,32.69 105.15,31.54 109.23,31.54 109.89,32.2 115.24,32.2 115.75,32.7 115.75,35.15 116.34,35.74 120.36,35.74 120.59,35.97 127.44,35.97 130.25,33.16 131.85,33.16 132.17,33.48 132.3,33.48 v9(132.47,33.31)
  IN2 w0.089: v9(180.11,21.26) 180.11,20.89 180.2,20.8 180.47,20.8 180.59,20.92 180.59,21.76 179.46,22.89 178.39,22.89 167.75,33.53 165.26,33.53 164.69,34.1 164.69,34.74 165.39,35.44 165.39,36.37 164.62,37.14 158.35,37.14 155.86,34.65 155.86,34.12 155.53,33.79 153.91,33.79 153.19,34.5 152.11,34.5 151.57,35.03 151.06,35.03 150.48,34.45 145.4,34.45 141.87,30.92 134.09,30.92 133.3,31.71 133.3,32.96 132.77,33.48 132.64,33.48 v9(132.47,33.31) ; v9(99.18,31.99) 99.01,32.16 95.86,32.16 95.37,31.67 84.35,31.67 80.21,35.81 77.31,35.81 76.82,36.3 76.82,37.39 76.43,37.78 75.56,37.78 73.01,40.34 71.84,40.34 68.37,43.81 66.92,43.81 65.76,44.98 58.85,44.98 58.3,45.52 55.7,45.52 55.13,44.95 53.65,44.95 52.68,43.98 46.7,43.98 45.69,42.96 43.3,42.96 v9(43.22,42.88)
SMBDAT3_R: length 41.3
  IN4 w0.089: v2(194.85,51.23) 194.77,51.15 194.77,50.77 194.21,50.22 194.21,48.4 193.15,47.34 193.15,44.86 192.16,43.87 183.98,43.87 180.97,46.88 179.68,46.88 179.54,46.74 179.54,46.57 179.78,46.32 v2(179.78,46.32) 179.78,43.89 179.33,43.44 178.38,43.44 178.31,43.51 177.76,43.51 176.91,44.37 176.91,44.52 175.29,46.14 175.18,46.14 v2(175.02,45.98)
  BOTTOM w0.127: J1.16 194.85,51.61 194.8,51.57 194.8,51.28 v2(194.85,51.23) ; 179.79,46.32 Q27.1 ; 179.79,46.32 v2(179.78,46.32) ; 179.79,46.32 179.14,46.32 179.05,46.41 179.05,47.21 R320.1 ; Q26.1 171.81,45.66 171.91,45.56 R331.1 171.91,44.04 172.04,43.91 173.13,43.91 v6(174.15,44.94) 174.15,44.94 174.15,45.85 174.28,45.98 RP32.4 v2(175.02,45.98)
SMBDATA: length 118.2
  TOP w0.127: v9(90.96,42.03) 91.11,42.03 91.2,41.94 RP8.3
  IN2 w0.089: v5(176.92,42.84) 177.01,42.75 177.01,42.36 176.22,41.57 161.31,41.57 160.56,42.32 155.66,42.32 155.43,42.55 146.35,42.55 143.82,40.02 141.7,40.02 141.23,39.55 137.27,39.55 136.73,40.1 132.74,40.1 132.03,39.39 123.94,39.39 123.6,39.73 117.66,39.73 117.55,39.62 107.49,39.62 103.34,43.77 96.83,43.77 95.31,42.24 93.13,42.24 92.62,42.75 91.47,42.75 91.18,42.47 91.18,42.39 91.18,42.39 91.18,42.25 v9(90.96,42.03) 91.13,41.86 91.13,41.75 90.99,41.61 88.28,41.61 86.88,43 86.88,44.2 85.31,45.78 80.71,45.78 79.84,44.91 79.18,44.91 78.85,45.24 v5(78.85,46.05)
  IN4 w0.089: v5(78.85,46.05) 78.83,46.08 v2(78.52,46.08) ; v2(173.72,45.24) 174.33,45.24 174.57,45 175.15,45 177,43.16 177,42.91 v5(176.92,42.84)
  BOTTOM w0.127: v2(78.52,46.08) 78.35,46.25 U16.AH1 ; Q26.6 172.54,45.66 172.39,45.51 172.39,44.65 172.5,44.53 R331.2 173.4,45.24 v2(173.72,45.24)
SMC_EXTSMI_N: length 62.4
  TOP w0.127: v4(127.7,47.17) 127.77,47.25 130.95,47.25 131.28,47.58
  IN1 w0.089: v9(117.43,44.18) 120.46,44.18 121.93,45.65 127.04,45.65 127.7,46.31 v4(127.7,47.17)
  IN2 w0.089: v5(85.35,52.66) 85.35,52.53 85.96,51.92 89.85,51.92 90.26,51.52 98.66,51.52 102.68,47.5 109.76,47.5 110.58,46.68 111.19,46.68 112.66,45.22 112.66,43.13 113.27,42.52 116.04,42.52 117.43,43.92 v9(117.43,44.18)
  IN3 w0.089: v5(85.35,52.66) 85.3,52.61 v2(85.01,52.61)
  BOTTOM w0.127: R292.1 84.59,52.66 84.14,53.11 81.98,53.11 TP83.1 81.54,52.94 80.91,52.94 79.47,51.5 U16.V1
SML0CLK: length 5.9
  BOTTOM w0.127: U16.AN1 78.06,43.3 79.22,43.3 81.23,45.31 82.27,45.31 82.51,45.55 R328.1
SML0DATA: length 6
  BOTTOM w0.127: U16.AK1 78.06,45.5 78.68,44.88 79.61,44.88 80.52,45.79 81.86,45.79 82.76,46.69 R322.1
SPI_CS#: length 36.3
  IN1 w0.089: v5(108.42,54.35) 108.07,54.7 107.45,54.7 107.44,54.69 106.43,54.69 105.79,54.05 101.78,54.05 101.05,54.78 92.86,54.78 92.24,54.16 92.24,53.6 89.62,50.98 86.17,50.98 85.85,50.66 83.64,50.66 83.59,50.72 83.36,50.72 v4(82.66,51.41)
  IN4 w0.102: v5(108.42,54.35) v2(108.79,54.35)
  BOTTOM w0.127: RP28.1 105.81,53.23 106.64,52.4 U15.1 109.53,52.4 109.64,52.51 109.64,52.91 v7(108.8,53.75) 108.79,53.76 v2(108.79,54.35)
SPI_SCK: length 40
  TOP w0.127: v4(82.69,48.98) 82.67,48.96 R307.2
  IN1 w0.089: v4(82.69,48.98) 82.99,49.28 84.21,49.28 84.55,49.62 86.36,49.62 86.69,49.95 90.12,49.95 93.25,53.09 100.37,53.09 100.44,53.17 100.44,53.5 100.31,53.62 97.59,53.62 v5(97.24,53.97)
  IN4 w0.089: v5(97.24,53.97) v2(96.91,53.97)
  BOTTOM w0.127: RP28.7 104.16,49.5 103.67,49 102.58,49 101.71,49.86 U15.6 99.91,49.86 99.65,49.61 98.41,49.61 v6(97.16,50.86) 96.91,51.11 v2(96.91,53.97)
SPI_SI: length 39.9
  IN1 w0.089: v4(82.67,49.48) 82.82,49.64 83.75,49.64 84.08,49.97 86.19,49.97 86.52,50.3 89.95,50.3 93.1,53.45 93.23,53.45 93.3,53.52 93.3,53.93 93.41,54.03 93.56,54.03 93.66,53.93 93.66,53.52 93.74,53.45 93.94,53.45 94.03,53.53 94.03,53.95 94.14,54.06 94.29,54.06 94.4,53.95 94.4,53.5 94.45,53.45 94.75,53.45 94.8,53.5 94.8,53.93 94.91,54.03 95.05,54.03 95.16,53.93 95.16,53.52 95.23,53.45 96.44,53.45 96.57,53.57 96.57,53.85 96.44,53.97 v5(96.05,53.97)
  IN4 w0.089: v5(96.05,53.97) v2(96.53,53.97)
  BOTTOM w0.127: RP28.5 104.74,49.49 103.85,48.59 U15.5 98.68,48.59 98.12,49.15 97.44,49.15 96.99,48.7 96.81,48.7 96.58,48.92 96.58,49.08 v7(96.91,49.41) 97.42,49.92 97.42,50.04 97.2,50.26 97,50.26 96.75,50 96.62,50 96.53,50.09 v2(96.53,53.97)
SPI_SO: length 41.4
  TOP w0.127: R299.2 82.67,50.2 v4(82.46,49.99)
  IN1 w0.089: v4(82.46,49.99) 83.6,49.99 83.92,50.31 86.03,50.31 86.36,50.64 89.79,50.64 92.59,53.45 92.59,54 93.02,54.44 100.72,54.44 101.46,53.7 105.94,53.7 106.58,54.35 v5(107.59,54.35)
  IN4 w0.102: v5(107.59,54.35) v2(107.96,54.35)
  BOTTOM w0.127: RP28.3 105.24,52.54 106.64,51.13 U15.2 v7(110.45,51.13) 110.45,52.84 109.26,54.03 109.26,54.39 108.93,54.72 108.33,54.72 v2(107.96,54.35)
SRTC_RST#: length 12.7
  TOP w0.127: v6(77.63,36.58) 75.55,34.5 v7(75.55,32.9) C162.1 R180.1
  BOTTOM w0.089: U16.AV6 74.92,40.14 74.92,38.5 75.4,38.03 75.4,37.49 75.55,37.34
  BOTTOM w0.127: v6(77.63,36.58) 76.74,36.58 76.39,36.94 75.96,36.94 75.55,37.34
SSD_PWREN: length 3.4
  TOP w0.127: PU9.3 165.91,35.47 v6(165.85,35.41) 165.85,35.14 165.92,35.06 PR95.1 165.46,34.48 165.3,34.63 PR94.2
SUS_ON: length 244.9
  TOP w0.127: PR40.1 118.84,45.54 117.48,46.89 117.48,53.37 117.13,53.73 117.13,55.3 117.41,55.59 120.36,55.59 120.66,55.88 120.66,56.95 119.72,57.89 119.72,58.75 119.47,59.01 119.03,59.01 118.86,59.19 118.86,60.66 119.16,60.96 v6(119.39,60.96) ; v9(139.38,61.85) 139.38,62.03 139.91,62.56 139.91,63.07 140.23,63.39 R16.1 141.03,63.88 141.03,64.69 140.93,64.8 140.93,64.8 140.55,65.18 R6.1 ; PR120.1 198.2,24.35 198.83,24.99 v4(199.69,24.99) ; v9(137.5,57.59) 137.62,57.59 U4.E7 ; Q40.2 114.43,22.31 v6(113.75,22.99)
  IN1 w0.089: v4(140.55,65.43) v5(140.55,66.13) ; v9(186.52,40.72) 189.82,37.42 189.82,32.47 191.22,31.07 193.61,31.07 v4(199.69,24.99) ; v9(182.97,40.72) 182.97,44.53 177.51,49.99 177.51,55.86 175.78,57.59 175.24,57.59 175.19,57.54 171.05,57.54 171.03,57.56 170.44,57.56 168.45,59.55 v5(168.45,61.54) ; v5(121.29,62.64) 119.62,60.96 v6(119.39,60.96)
  IN2 w0.089: v5(132.55,29.24) 132.55,29.19 131.58,28.22 124.75,28.22 121.24,24.72 119.69,24.72 118.2,23.22 113.98,23.22 v6(113.75,22.99) ; v9(139.38,61.85) 139.02,61.5 138.64,61.5 137.88,60.74 137.88,57.94 137.53,57.59 v9(137.5,57.59) ; v9(182.97,40.72) v9(186.52,40.72)
  IN4 w0.089: v5(168.45,61.54) 167.11,62.89 150.91,62.89 150.56,62.54 147.66,62.54 144.07,66.13 v5(140.55,66.13) 139.9,65.49 129.96,65.49 127.92,63.45 122.11,63.45 v5(121.29,62.64) ; v5(132.55,29.24) 132.55,29.67 v2(132.52,29.7)
  BOTTOM w0.127: v2(132.52,29.7) 131.91,30.31 131.91,42.4 126.17,48.14 126.17,52.86 123.76,55.27 123.76,56.52 125,57.76 131.43,57.76 132.6,58.93 132.6,62.39 131.73,63.25 121.68,63.25 v6(119.39,60.96) 119.39,60 115.94,56.54 112.53,56.54 v7(111.52,57.56) 111.47,57.6 PR175.1
SUSACK#: length 84.8
  TOP w0.127: v4(142.72,60.4) 142.72,60.48 141.21,58.98 U4.C13
  IN1 w0.089: v6(122.12,62.61) 122.12,63.03 124.88,65.79 127.82,65.79 128.99,66.96 133.94,66.96 134.45,66.45 138.62,66.45 138.8,66.63 141.15,66.63 141.51,66.26 141.51,65.31 143.62,63.2 143.62,61.12 142.96,60.45 142.77,60.45 v4(142.72,60.4)
  BOTTOM w0.127: v6(122.12,62.61) 120.46,60.94 120.46,59.34 116.9,55.78 114.36,55.78 113.52,54.94 113.52,53.8 114.16,53.17 114.16,47.55 113.17,46.56 107.93,46.56 v7(106.41,45.04) 105.17,43.79 105.17,42.47 104.37,41.67 101.78,41.67 100.31,43.13 96.81,43.13 95.65,44.29 95.65,45.03 95.06,45.62 93.96,45.62 93.43,46.16 93.43,46.74 93.2,46.97 92.62,46.97 92.39,47.2 88.1,47.2 87.88,46.98 R324.1
SUSACK#_R: length 11.4
  BOTTOM w0.076: 78.71,45.39 78.68,45.39 78.58,45.5 78.45,45.5 78.16,45.78 77.64,45.78 U16.AK2
  BOTTOM w0.127: 78.71,45.39 79.53,45.39 80.17,46.03 81.67,46.03 82.75,47.11 84.17,47.11 84.54,47.48 84.75,47.69 R319.2 85.33,47.69 85.77,47.25 86.01,47.25 86.6,46.66 R324.2
SUSCLK: length 131.6
  TOP w0.127: v7(184.52,25.63) 183.98,25.1 R205.2 183.48,25.77 v6(183.3,25.96)
  IN3 w0.089: v6(183.3,25.96) 182.5,26.75 182.33,26.75 182.33,26.75 181.94,26.75 181.94,26.75 181.61,26.75 181.61,26.75 181.52,26.75 181.24,27.03 181.24,29.91 179.69,31.46 179.69,38.51 178.93,39.27 168.84,39.27 163.89,44.23 163.58,44.23 160.82,46.98 155.81,46.98 155.57,46.75 145.51,46.75 141.69,42.93 136.64,42.93 135.7,41.99 130.82,41.99 129.25,43.57 114.97,43.57 111.36,47.17 103.36,47.17 101.23,49.31 93,49.31 91.82,48.13 84.14,48.13 83.96,48.32 81.47,48.32 80.45,47.3 75.68,47.3 75.27,47.71 v2(74.73,47.71)
  BOTTOM w0.127: U16.AE6 v2(74.73,47.71)
SWR_GND:
  vias: v1(96.1,39.2) v1(96.1,38.56) v1(96.1,37.8) v1(96.99,39.2) v1(97.88,39.2) v1(97.88,37.93) v1(98.26,36.66) v1(98.77,39.2) v1(98.77,37.93) v1(98.89,40.09) v1(99.4,36.66) v1(99.65,39.2) v1(99.65,37.93) v1(100.16,40.09) v1(100.54,39.2) v1(100.54,37.93) v1(101.43,40.09) v1(101.56,39.2) v1(101.56,38.31) v1(102.7,40.09) v1(102.7,37.04) v1(103.08,39.45) v1(103.21,37.67) v1(103.85,37.16) v2(96.1,39.2) v2(96.1,38.56) v2(96.1,37.8) v2(96.99,39.2) v2(97.88,39.2) v2(97.88,37.93) v2(98.26,36.66) v2(98.77,39.2) v2(98.77,37.93) v2(98.89,40.09) v2(99.4,36.66) v2(99.65,39.2) v2(99.65,37.93) v2(100.16,40.09) v2(100.54,39.2) v2(100.54,37.93) v2(101.43,40.09) v2(101.56,39.2) v2(101.56,38.31) v2(102.7,40.09) v2(102.7,37.04) v2(103.08,39.45) v2(103.21,37.67) v3(96.48,39.32) v3(96.48,38.31) v3(97.37,37.16) v3(97.62,36.28) v3(97.62,35.77) v3(97.88,37.16) v3(98.89,36.28) v3(98.89,35.77) v3(100.41,37.42) v3(100.41,36.02) v3(103.46,39.07) v3(103.46,38.69) v4(96.48,39.32) v4(96.48,38.31) v4(97.37,37.16) v4(97.62,36.28) v4(97.62,35.77) v4(97.88,37.16) v4(98.89,36.28) v4(98.89,35.77) v4(100.41,37.42) v4(100.41,36.02) v5(96.99,38.56) v5(98.26,39.83) v5(98.26,38.56) v5(98.26,37.29) v5(98.26,36.02) v5(99.27,36.02) v5(99.53,39.83) v5(99.53,38.56) v5(99.53,37.29) v5(100.8,39.83) v5(100.8,38.56) v5(102.07,39.83) v5(103.85,37.67) v7(100.29,37.16) v8(96.1,39.2) v8(96.1,38.56) v8(96.1,37.8) v8(96.99,39.2) v8(97.88,39.2) v8(97.88,37.93) v8(98.26,36.66) v8(98.77,39.2) v8(98.77,37.93) v8(98.89,40.09) v8(99.4,36.66) v8(99.65,39.2) v8(99.65,37.93) v8(100.16,40.09) v8(100.54,39.2) v8(100.54,37.93) v8(101.43,40.09) v8(101.56,39.2) v8(101.56,38.31) v8(102.7,40.09) v8(103.08,39.45)
SYS_PWR_SW#: length 19.3
  TOP w0.127: v7(123.33,62.59) C15.1 123.91,61.56 124.15,61.32 D3.2 125.23,61.72 R21.2 125.23,63.19 v9(124.96,63.45) ; U4.E2 135.46,57.98 v4(135.41,58.03)
  IN1 w0.089: v4(135.41,58.03) 135.19,58.25 134.56,58.25 133.9,58.9 131.43,58.9 131.11,58.58 v9(130.79,58.58)
  IN2 w0.089: v9(124.96,63.45) 127.15,61.27 127.15,59.51 127.98,58.68 129.7,58.68 129.9,58.88 130.5,58.88 v9(130.79,58.58)
SYS_PWROK: length 74.2
  TOP w0.127: v9(139.86,55.87) 139.79,55.95 139.54,55.95 U4.J10
  IN1 w0.089: v9(130.39,50.82) 130.39,48.17 129.3,47.07 129.3,45.4 127.77,43.87 124.14,43.87 121.7,41.43 121.7,41.2 v5(122.23,40.67)
  IN2 w0.089: v9(139.86,55.87) 139.86,51.72 139.05,50.91 137.93,50.91 137.42,51.41 135.19,51.41 134.59,50.82 v9(130.39,50.82)
  IN4 w0.089: v2(103.21,42.5) 105.75,39.96 105.75,39.88 107.17,38.46 110.02,38.46 110.37,38.1 110.73,38.1 111.08,38.46 113.45,38.46 115.29,40.3 121.87,40.3 v5(122.23,40.67)
  BOTTOM w0.127: R311.1 85.97,48.9 94.22,48.9 96.2,46.92 96.2,46 96.99,45.22 v7(99.55,45.22) 101.64,45.22 103.21,43.64 v2(103.21,42.5)
SYS_PWROK_R: length 9.5
  BOTTOM w0.076: 78.45,47.18 78.35,47.28 77.82,47.28 77.54,47 U16.AG2
  BOTTOM w0.127: 78.45,47.18 78.58,47.05 81.32,47.05 81.65,47.38 81.65,47.88 82.79,49.03 R310.1 83.43,49.45 84.04,49.45 84.21,49.28 84.21,49.15 84.39,48.98 84.96,48.98 R311.2
SYS_RESET#: length 9.7
  BOTTOM w0.127: U16.AC3 77.15,49.65 78.15,49.65 78.39,49.89 80.15,49.89 80.93,50.68 81.37,50.68 TP88.1 82.51,51.16 82.71,51.36 82.71,51.47 R295.1 83.36,51.16 84.43,51.16 R296.1
SYS_SHDN#: length 10
  TOP w0.127: R136.2 15.31,41.27 16.33,40.25 U8.7 19.76,40.25 Q7.1 20.58,39.15 v7(19.14,37.7)
T_CPU: length 48.8
  TOP w0.127: v7(171.1,64.34) v4(172.07,64.34) 172.07,64.85 172.16,64.94 R8.2 ; U4.F9 137.97,57.48 v9(137.88,57.38)
  IN1 w0.089: v9(170.77,57.97) 170.77,63.05 v4(172.07,64.34)
  IN2 w0.089: v9(170.77,57.97) 158.73,57.97 158.02,57.26 149.67,57.26 145.3,61.62 141.84,61.62 141.46,61.24 138.69,61.24 138.08,60.63 138.08,58.83 138.11,58.81 138.11,57.61 v9(137.88,57.38)
TD_IREF: length 5.6
  TOP w0.127: v7(69.38,61.85) 70.05,61.18 R2.2 70.52,59.56 v4(70.52,59.54)
  IN1 w0.089: v4(70.52,59.54) 71.31,60.33 v5(71.41,60.33)
  IN3 w0.089: v2(70.42,61.07) 70.43,61.06 70.43,60.71 70.72,60.41 71.33,60.41 v5(71.41,60.33)
  BOTTOM w0.127: U16.B12 70.42,61.07 v2(70.42,61.07)
TESTLOW_0: length 5.9
  BOTTOM w0.127: U16.C35 56.83,60.74 56.83,60.86 56.78,60.91 56.78,61.19 56.83,61.24 56.83,61.52 56.78,61.57 56.78,61.83 54.9,63.71 v6(54.9,64.16) 54.76,64.31 RP25.1
TESTLOW_1: length 7.8
  BOTTOM w0.127: U16.C34 56.61,60.09 56.12,60.58 56.12,60.91 56.14,60.94 56.14,61.19 56.12,61.22 56.12,61.57 56.14,61.6 56.14,61.85 55.47,62.53 54.76,62.53 v6(54.24,63.05) 54.18,63.1 RP25.3
TESTLOW_2: length 34.6
  IN3 w0.089: v2(53.96,62.44) 54.24,62.44 57.52,59.16 64.2,59.16 65.19,58.17 67.75,58.17 68.49,57.43 68.49,56.58 68.7,56.37 71.1,53.97 71.1,50.02 72.19,48.93 72.19,46.78 72.72,46.26 72.73,46.26 73.15,45.83 73.15,45.74 73.55,45.34 73.57,45.34 v2(73.87,45.04)
  BOTTOM w0.127: v2(53.96,62.44) 53.58,62.82 v6(53.58,64.16) 53.58,64.8 53.68,64.9 RP25.5 ; U16.AK8 73.71,45.2 v2(73.87,45.04)
TESTLOW_3: length 35.3
  IN3 w0.089: v2(53.39,62.44) 57.1,58.73 64.27,58.73 65.19,57.81 67.27,57.81 68.16,56.93 68.16,56.34 70.75,53.75 70.75,50.02 71.99,48.78 71.99,46.72 72.64,46.07 72.65,46.07 72.91,45.81 72.91,44.94 73.24,44.61 v2(73.7,44.61)
  BOTTOM w0.127: RP25.7 53.11,64.84 52.92,64.65 52.92,63.48 v6(52.69,63.25) 52.69,63.14 v2(53.39,62.44) ; v2(73.7,44.61) 73.7,44.61 U16.AL8
THERM_ALERT#: length 4.7
  TOP w0.127: U8.8 17.26,40.75 17.03,40.97 17.03,41.84 17.47,42.28 R137.2 17.76,42.91 17.87,42.8 18.55,42.8 v7(18.67,42.93)
THERM_STP#: length 130.3
  TOP w0.127: v4(22.62,40.97) 22.57,40.92 Q7.3 23.86,40.09 v7(23.96,40.19) ; R75.2 127.72,53.41 v4(127.73,53.42) 127.86,53.29 128.67,53.29 129.5,54.12 D6.1 129.5,55.73 129.91,56.14 131.15,56.14 131.4,56.39 PQ1.2
  IN1 w0.089: v9(116.06,56.01) 115.98,56.09 111.03,56.09 110.38,55.43 105.98,55.43 105.35,54.8 102.24,54.8 101.49,55.55 92.52,55.55 91.14,54.18 91.14,53.57 89.29,51.72 85.99,51.72 85.92,51.79 81.91,51.79 81.72,51.97 78.88,51.97 78.39,51.49 77.4,51.49 76.97,51.92 75.17,51.92 74.66,51.41 73.47,51.41 73.14,51.08 73.14,48.89 72.8,48.56 71.04,48.56 70.01,47.53 68.31,47.53 67.85,47.07 67.37,47.07 66.08,45.78 59.9,45.78 59.65,46.03 55.84,46.03 54.92,45.11 53.63,45.11 52.66,44.15 47.08,44.15 41.74,38.82 38,38.82 37.42,38.24 32.49,38.24 29.79,40.93 27.69,40.93 25.86,39.1 24.49,39.1 v4(22.62,40.97) ; v9(127.98,53.95) 127.98,53.78 127.73,53.53 v4(127.73,53.42)
  IN2 w0.089: v9(116.06,56.01) 116.16,55.91 117.48,55.91 117.92,56.34 125.87,56.34 127.98,54.23 v9(127.98,53.95)
THERMAL_PWR_EN: length 96.9
  TOP w0.127: v4(166.2,13.16) 166.2,12.37 167.28,11.3 PR143.1 168.79,10.84 168.79,9.73 169.55,8.97 v7(169.94,8.97) 171.92,8.97 172.78,9.83 PR146.2
  IN1 w0.089: v9(151.72,61.32) 151.01,61.32 150.12,60.43 150.12,57.94 159.57,48.49 162.67,48.49 164.27,46.89 164.78,46.89 165.22,46.45 165.22,45.87 166.77,44.33 166.77,29.87 169.55,27.08 169.55,18.42 166.2,15.07 v4(166.2,13.16) ; v9(138.41,64.19) 138.65,63.96 138.65,62.25 138.73,62.17 138.73,61.44 137.78,60.49 137.78,59.32 137.97,59.14 138.28,59.14 138.73,58.69 138.73,58.27 138.8,58.2 139.23,58.2 139.28,58.26 139.75,58.26 140.07,57.93 140.47,57.93 v4(140.51,57.98)
  IN2 w0.089: v9(151.72,61.32) 151.67,61.32 150.63,62.36 150.63,63.55 150.09,64.09 149.64,64.09 148.91,64.81 146.71,64.81 145.96,64.06 138.54,64.06 v9(138.41,64.19)
THERMAL_PWR_EN_R: length 3.7
  TOP w0.127: PU16.5 170.94,13.3 v6(171.23,13.01) 171.64,12.6 PR145.1 PR146.1
THERMAL_STP#_CTRL: length 172.9
  TOP w0.127: U4.D12 140.53,58.46 140.53,58.46 140.76,58.23 v9(140.76,58.23) ; v4(45.15,43.33) 43.39,41.58 43.39,40.09 40.07,36.76 31.98,36.76 28.25,40.49 25.38,40.49 24.52,39.63 23.5,39.63 22.26,38.38 22.26,36.91 22.06,36.71 21.26,36.71 R160.1 ; v4(109.31,55.91) v7(109.31,62.97) 109.31,63.58 111.92,66.2 114.16,66.2 115.2,65.16 124.24,65.16 126.3,67.21 141.46,67.21 v4(141.69,66.98)
  IN1 w0.089: v4(109.31,55.91) 109.22,55.83 105.82,55.83 105.19,55.19 102.4,55.19 101.65,55.95 92.27,55.95 90.75,54.42 90.75,53.73 89.42,52.4 89,52.4 88.9,52.3 87.44,52.3 86.23,53.51 79.79,53.51 79.19,54.11 77.99,54.11 75.85,56.25 75.8,56.25 75.41,56.64 75.4,56.64 75.09,56.95 73.27,56.95 72.73,56.42 72.73,55 72.94,54.79 72.94,54.09 72.73,53.88 72.73,49.24 72.51,49.02 70.82,49.02 69.76,47.96 68.16,47.96 67.73,47.53 67.27,47.53 65.95,46.21 60.31,46.21 59.95,46.56 52.61,46.56 52.05,46 52.05,45.7 51.65,45.29 47.11,45.29 v4(45.15,43.33) ; v4(141.69,66.98) 144.59,64.09 144.59,60.23 146.76,58.06 146.76,57.16 v9(146.9,57.03)
  IN2 w0.089: v9(146.9,57.03) 146.87,57 145.37,57 144.54,57.84 142.96,57.84 142.57,58.23 140.78,58.23 v9(140.76,58.23)
TOUCH_PAD_CLK: length 106.6
  TOP w0.127: RP10.2 153.55,20.84 v6(153.54,20.83)
  IN1 w0.089: v6(153.54,20.83) 153.74,21.03 154.93,21.03 156.44,22.54 156.44,25.75 155.87,26.32 155.87,33.91 156,34.05 156,35.45 156.61,36.06 156.61,44.84 v9(156.78,45.01)
  IN2 w0.089: v5(91.88,53.84) 92.24,54.2 92.24,54.39 92.54,54.69 98.31,54.69 103.73,49.27 110.87,49.27 111.39,48.75 111.92,48.75 115.05,45.62 117.81,45.62 118.91,44.52 122.05,44.52 122.81,43.76 138.45,43.76 138.85,43.36 141.94,43.36 144.2,45.62 150.78,45.62 151.44,46.28 156.02,46.28 156.61,45.69 156.61,45.18 v9(156.78,45.01)
  IN4 w0.089: v2(91.5,53.89) 91.83,53.89 v5(91.88,53.84)
  BOTTOM w0.127: Q25.4 89.84,52.52 89.67,52.68 89.67,54.03 89.93,54.28 91.25,54.28 91.5,54.03 v2(91.5,53.89) ; R389.1 154.84,21.11 154.84,21.27 154.74,21.37 154.31,21.37 153.93,20.98 153.69,20.98 v6(153.54,20.83)
TOUCH_PAD_CLK_R: length 1.9
  BOTTOM w0.127: JP1.3 154.55,19.15 154.86,19.46 154.86,19.67 R389.2
TOUCH_PAD_DAT: length 101.2
  TOP w0.127: RP10.4 153.6,21.49 v6(153.54,21.55)
  IN1 w0.089: v6(153.54,21.55) 153.71,21.37 154.78,21.37 156.09,22.68 156.09,25.61 155.52,26.17 155.52,34.06 155.66,34.19 155.66,35.59 156.27,36.2 156.27,44.84 v9(156.1,45.01)
  IN2 w0.089: v9(156.1,45.01) 156.27,45.18 156.27,45.54 155.87,45.94 151.59,45.94 150.93,45.28 144.35,45.28 142.08,43.02 138.7,43.02 138.31,43.41 122.67,43.41 121.91,44.18 118.77,44.18 117.66,45.28 114.9,45.28 111.78,48.4 111.25,48.4 110.73,48.92 103.59,48.92 98.17,54.35 92.68,54.35 92.58,54.25 92.58,54.2 v5(92.94,53.84)
  IN4 w0.089: v5(92.94,53.84) 92.6,53.84 v2(92.56,53.8)
  BOTTOM w0.127: R390.1 155.22,21.11 155.22,21.43 154.9,21.75 154.16,21.75 153.78,21.37 153.72,21.37 v6(153.54,21.55) ; Q25.1 v2(92.56,53.8)
TOUCH_PAD_DAT_R: length 1.9
  BOTTOM w0.127: R390.2 155.24,19.72 155.24,19.46 155.55,19.15 JP1.2
TOUCHPAD_EN: length 142.3
  TOP w0.127: R87.1 83.36,53.17 R79.2 84.14,54.33 R69.2 ; v9(187.28,24.08) v7(187.28,27.08) 187.28,28.86 188.27,29.85 PR110.1
  IN1 w0.089: v4(83.98,52.66) v5(83.63,52.66) ; v9(165.31,34.47) 165.31,34.5 165.29,34.52 163.38,34.52 161.88,36.02 160,36.02 159.13,36.9 159.13,45.31 158.66,45.78 154.16,45.78 153.52,45.14 153.52,43.72 152.61,42.8 151.8,42.8 v9(150.2,44.4)
  IN2 w0.089: v5(83.63,52.66) 83.6,52.63 83.6,51.97 84.72,50.86 85.84,50.86 86.09,51.11 89.29,51.11 89.78,50.63 98.31,50.63 98.6,50.33 102.14,46.79 106.08,46.79 107.88,44.99 107.88,42.68 108.59,41.98 116.43,41.98 117.84,43.39 120.33,43.39 121.12,42.6 124.98,42.6 125.71,41.86 126.4,41.86 126.83,42.3 133.23,42.3 133.72,41.81 134.1,41.81 134.29,42 137.49,42 138.52,40.97 140.55,40.97 141.06,41.48 142.58,41.48 145.04,43.95 145.37,43.95 145.55,44.12 149.92,44.12 v9(150.2,44.4) ; v9(165.31,34.47) 169.4,34.47 170.45,33.42 170.45,33.2 170.68,32.96 170.91,32.96 177.28,26.6 177.28,25.23 178.42,24.08 182.08,24.08 182.46,23.7 182.97,23.7 183.35,24.08 v9(187.28,24.08)
TOUCHPAD_EN_R: length 3.9
  TOP w0.127: PU14.5 190.91,29.06 PR111.1 PR110.2 188.99,29.07 v7(188.99,29.06)
TOUCHPAD_INTR#: length 20.8
  IN3 w0.089: v8(161.15,18.88) 160.97,19.05 153.59,19.05 v2(151.85,20.79)
  IN4 w0.089: v2(160.88,11.38) 160.88,12.1 161.15,12.37 v8(161.15,18.88)
  BOTTOM w0.127: Q36.1 161.91,9.96 v7(162.49,10.55)
  BOTTOM w0.254: Q36.1 161.15,10.56 160.88,10.83 v2(160.88,11.38)
TOUCHPAD_INTR#_PCH: length 142.4
  IN1 w0.089: v9(149.69,44.4) 151.75,42.35 152.63,42.35 153.88,43.6 153.88,44.98 154.29,45.39 158.43,45.39 158.79,45.04 158.79,36.71 160,35.49 162.04,35.49 162.92,34.61 162.92,30.66 165.01,28.58 165.01,13.74 v6(165.29,13.47) ; v4(84.01,51.39) 85.05,51.39 v5(85.09,51.36)
  IN2 w0.089: v5(85.09,51.36) 85.16,51.43 89.63,51.43 90.1,50.96 98.66,50.96 102.63,46.99 106.23,46.99 108.14,45.09 108.14,42.7 108.67,42.17 116.32,42.17 117.74,43.59 120.63,43.59 121.37,42.85 125.28,42.85 125.88,42.26 126.21,42.26 126.53,42.57 137.8,42.57 138.87,41.51 140.14,41.51 140.75,42.12 142.61,42.12 144.99,44.51 149.59,44.51 v9(149.69,44.4)
  IN3 w0.089: v2(74.08,52.52) 74.39,52.84 74.94,52.84 75.27,52.51 75.27,51.49 75.65,51.11 78.78,51.11 79.26,50.63 83.66,50.63 84.39,51.36 v5(85.09,51.36)
  BOTTOM w0.127: Q36.3 161.2,7.98 v7(162.49,9.28) 165.29,12.07 v6(165.29,13.47)
TOUCHSCREEN_EN: length 135
  TOP w0.127: PR67.1 187.8,40.97 186.85,41.91 186.85,43.74 v7(186.9,43.79) 186.9,44.23 186.55,44.58 186.55,46.23 v9(186.83,46.51) ; R79.1 84.14,53.79 84.59,54.23 84.59,55.73 v4(84.67,55.81)
  IN1 w0.089: v5(85.05,55.91) 84.95,55.81 v4(84.67,55.81)
  IN2 w0.089: v5(88.66,53.52) 88.86,53.32 89.01,53.32 90.38,51.95 98.82,51.95 102.88,47.88 109.92,47.88 110.75,47.05 111.34,47.05 113.04,45.34 113.04,43.64 113.8,42.88 115.88,42.88 116.8,43.79 116.8,44.23 117.05,44.48 117.59,44.48 118.27,43.79 121.4,43.79 122.12,43.07 129.16,43.07 129.45,42.78 138.03,42.78 138.41,42.4 142.55,42.4 144.87,44.71 166.35,44.71 166.94,44.12 171.21,44.12 172.22,45.13 178.41,45.13 179.89,46.61 186.73,46.61 v9(186.83,46.51)
  IN3 w0.089: v5(88.66,53.52) 87.49,53.52 86.2,54.82 85.96,54.82 85.05,55.73 v5(85.05,55.91) 85.05,55.91 84.76,56.2 84.6,56.2 84.32,56.49 84,56.49 83.32,55.81 80.52,55.81 80.31,56.01 78.11,56.01 77.15,55.05 77.15,54.41 76.84,54.11 76.41,54.11 76.17,53.87 75.64,53.87 75.58,53.93 75.57,53.93 75.37,54.13 74.37,54.13 v2(74.08,54.42)
TOUCHSCREEN_EN_R: length 4.3
  TOP w0.127: v7(187.41,42.24) 187.91,41.75 PR67.2 PR68.1 189.32,42.2 189.93,42.82 PU5.3
TOUCHSCREEN_SLEEP#: length 105.9
  TOP w0.127: v4(194.66,58.25) 194.66,57.74 194.65,57.73 D8.2
  IN1 w0.089: v5(202.63,38.94) 202.91,39.21 202.91,42.12 201.7,43.32 201.7,47.59 199.37,49.92 199.37,52.58 198.13,53.83 197.55,53.83 194.66,56.71 v4(194.66,58.25)
  IN4 w0.089: v2(202.22,38.94) v5(202.63,38.94)
  BOTTOM w0.127: JP2.6 148.61,12.39 153.76,7.24 161.4,7.24 166.79,12.63 169.1,12.63 170.77,14.3 180.93,14.3 181.19,14.56 186.99,14.56 v7(187.03,14.6) 187.59,15.16 187.59,24.29 187.54,24.34 187.54,28.4 194.78,35.64 196.12,35.64 199.42,38.94 v2(202.22,38.94)
TOUCHSCREEN_SLP#: length 74.1
  TOP w0.127: R76.1 195.93,52.91 v4(195.64,52.91) 195.31,52.58 v7(195.16,52.58) ; U4.C1 v9(135.08,58.98)
  IN1 w0.089: v4(195.64,52.91) 192.49,56.06 v9(191.22,56.06)
  IN2 w0.089: v9(191.22,56.06) 190.87,56.42 189.44,56.42 188.53,57.33 180.38,57.33 179.87,56.82 176.97,56.82 176.11,57.69 175.6,57.69 174.36,58.93 154.67,58.93 154.39,58.65 149.92,58.65 148.09,60.48 148.09,61.14 149.08,62.13 149.08,62.69 148.06,63.71 146.69,63.71 146.06,63.07 135.62,63.07 135.06,62.51 135.06,59 v9(135.08,58.98)
TP_CLK: length 1.8
  BOTTOM w0.127: L4.2 149.84,19.55 149.84,19.31 149.55,19.01 JP1.8
TP_DATA: length 1.9
  BOTTOM w0.127: L5.2 150.23,19.53 150.23,19.36 150.55,19.03 JP1.7
TP_DC_TEST_A4: length 8
  IN3 w0.089: v2(76.54,62.99) 75.91,63.63 75.91,66.55 v2(74.46,68)
  BOTTOM w0.127: v2(76.54,62.99) 76.12,62.57 U16.A4 ; TP48.1 74.15,68 v2(74.46,68)
TP_DC_TEST_A60: length 5.7
  BOTTOM w0.127: TP51.1 40.8,66.48 40.8,64.7 40.98,64.52 40.98,62.41 41.29,62.1 U16.A60
TP_DC_TEST_A62: length 4.5
  BOTTOM w0.127: U16.A62 39.98,63.95 38.44,65.49 TP58.1
TP_DC_TEST_AV1: length 6.6
  BOTTOM w0.127: TP130.1 82.66,37.29 82.17,37.29 79.38,40.09 78.72,40.09 78.41,40.4 U16.AV1
TP_DC_TEST_AW1: length 6.3
  BOTTOM w0.127: U16.AW1 78.49,39.2 79.46,39.2 80.86,37.8 80.86,36.4 81.11,36.15 TP138.1
TP_DC_TEST_AW63: length 5.2
  BOTTOM w0.127: U16.AW63 38.77,39.66 35.65,36.53 TP132.1
TP_DC_TEST_AY60: length 8.5
  BOTTOM w0.127: TP131.1 34.77,36.01 36.14,36.01 38.62,38.49 40.67,38.49 U16.AY60
TP_DC_TEST_B2: length 3.3
  IN1 w0.089: v4(79.21,63.45) 78.62,63.45 77.87,62.71 v5(77.87,61.99)
  IN4 w0.089: v2(77.86,61.57) 77.87,61.59 v5(77.87,61.99)
  BOTTOM w0.127: U16.B2 77.86,61.56 v2(77.86,61.57)
TPM_LPC_PD: length 97.6
  TOP w0.127: U6.28 148.52,56.43 147.41,57.54 R48.2 147.42,57.98 147.94,58.5 147.94,61.13 147.99,61.18 147.99,62.36 v4(148.19,62.56) ; v9(132.47,56.98) 133.03,56.42 133.03,55.5 133.23,55.3 133.23,52.86 132.37,52 131.24,52 v4(130.76,51.52)
  IN1 w0.089: v9(147.53,65.87) 147.74,65.66 147.74,64.5 148.19,64.04 v4(148.19,62.56) ; v4(130.76,51.52) 131.35,50.92 131.35,47.73 130.54,46.92 130.54,42.62 130.2,42.28 130.2,40.71 v5(129.85,40.37)
  IN2 w0.089: v9(132.47,56.98) 132.24,57.21 132.24,64.06 133.95,65.77 139.05,65.77 139.31,65.51 140.95,65.51 141.13,65.33 145.83,65.33 146.36,65.87 v9(147.53,65.87)
  IN4 w0.089: v5(129.85,40.37) 124.61,40.37 124.07,39.83 115.51,39.83 115.19,39.51 115.19,39.51 113.62,37.95 111.26,37.95 110.93,37.62 110.17,37.62 109.81,37.98 105.98,37.98 105.23,38.73 105.23,39.81 104.54,40.5 104.07,40.5 102.58,42 v2(102.58,42.5)
  BOTTOM w0.127: v2(102.58,42.5) 102.58,43.08 v7(101.79,43.87) 100.97,44.68 98.08,44.68 97.9,44.51 96.91,44.51 96.34,45.08 96.34,45.33 95.67,46 95.67,46.66 94.24,48.09 R315.2
TPM_PWR_EN: length 105.7
  TOP w0.127: v6(164.63,47.71) 164.63,47.43 163.67,46.47 v4(163.67,46.44) ; R143.1 v4(75.76,41.89)
  IN1 w0.089: v5(75.7,42.31) 75.7,42.32 75.72,42.29 75.72,42.16 75.76,42.12 v4(75.76,41.89) ; v4(163.67,46.44) v5(163.67,43.79)
  IN3 w0.089: v5(75.7,42.31) 75.7,43.85 v2(75.55,44) ; v2(75.68,46.82) 75.8,46.94 80.55,46.94 81.72,48.11 83.89,48.11 84.07,47.94 91.9,47.94 92.96,49 101.25,49 103.29,46.97 111.15,46.97 114.86,43.26 129.17,43.26 130.97,41.46 135.65,41.46 136.8,42.61 141.66,42.61 145.61,46.56 156.31,46.56 156.49,46.73 160.73,46.73 v5(163.67,43.79)
  BOTTOM w0.127: v2(75.68,46.82) 75.66,46.8 U16.AG5 75.05,46.47 75.05,45.64 75.55,45.14 v2(75.55,44)
TPM_RST#: length 115.2
  TOP w0.127: v4(151.17,61.62) 151.17,62.11 151.67,62.62 v7(152.51,62.62) 153.4,62.62 154.45,61.56 U1.1
  IN1 w0.089: v5(152.18,44.07) 152.18,48.72 152.23,48.77 152.23,52.73 149.03,55.94 149.03,60.41 150.25,61.62 v4(151.17,61.62)
  IN3 w0.089: v8(140.29,37.95) 140.32,37.95 140.6,38.23 144.15,38.23 146.11,40.19 147.53,40.19 151.42,44.07 v5(152.18,44.07)
  IN4 w0.089: v8(140.29,37.95) 136.48,37.95 135.47,38.97 128.79,38.97 128.52,39.23 125.08,39.23 124.53,38.69 115.97,38.69 114.09,36.81 111.8,36.81 110.9,35.91 106.08,35.91 103.65,33.48 96.76,33.48 95.95,34.29 95.95,36.35 94.99,37.3 94.99,39.72 94.73,39.98 90.69,39.98 89.16,38.46 86.47,38.46 86.04,38.03 82.18,38.03 80.3,39.91 78.88,39.91 78.42,40.37 78.42,42.23 v2(78.7,42.5)
  BOTTOM w0.127: v2(78.7,42.5) U16.AP1
UART1_CTS: length 157
  TOP w0.127: U13.7 184.81,28.33 185.32,27.82 v6(186.19,27.82)
  IN4 w0.089: v2(75.91,57.1) 75.91,57.26 76.04,57.4 76.22,57.4 76.72,57.89 79.72,57.89 80.52,57.08 84.35,57.08 84.74,56.7 86.29,56.7 86.95,56.04 88.35,56.04 89.31,55.08 102.42,55.08 102.76,54.74 105.71,54.74 106.47,53.97 113.92,53.97 114.3,54.35 119.02,54.35 119.31,54.64 121.29,54.64 121.83,54.09 127.6,54.09 128.06,54.55 129.11,54.55 129.6,54.05 133.48,54.05 133.85,54.42 155.12,54.42 155.81,53.73 160.26,53.73 161.76,52.23 167.52,52.23 169.77,49.97 169.77,47.68 171.12,46.33 171.12,43 173.92,40.2 181.38,40.2 182.18,41 186.75,41 188.73,39.02 188.73,32.75 188.72,32.73 188.72,32.7 187.21,31.19 187.21,29.7 186.19,28.68 v6(186.19,27.82)
  BOTTOM w0.127: v6(186.19,27.82) 184.95,27.82 183.22,29.54 183.22,38.02 182.84,38.4 182.84,39.96 181.75,41.05 RP34.3 ; U16.J4 75.91,56.86 v2(75.91,57.1)
UART1_CTS_R: length 5.6
  TOP w0.127: U13.5 182.21,28.33 v6(181.88,27.99) 181.56,27.99 181.31,28.24 R192.1
  BOTTOM w0.127: CN4.34 181.82,29.15 182.2,28.77 182.2,28.32 v6(181.88,27.99)
UART1_RTS: length 154.8
  TOP w0.127: v6(186.79,29.86) 186.79,29 186.16,28.37 185.4,28.37 185.04,28.73 U13.8
  IN4 w0.089: v2(77.15,57.1) 77.53,57.48 79.28,57.48 79.8,56.97 79.8,56.8 81.24,55.35 88.07,55.35 89.23,54.19 95.62,54.19 95.79,54.36 99.04,54.36 99.36,54.05 105.35,54.05 106.12,53.28 114.25,53.28 114.63,53.66 119.34,53.66 119.58,53.9 120.91,53.9 121.45,53.37 133.77,53.37 134.14,53.74 154.3,53.74 155.2,52.84 160.13,52.84 161.72,51.25 167.51,51.25 169.09,49.67 169.09,44.08 169.76,43.4 169.76,43.39 173.67,39.48 181.7,39.48 182.49,40.26 186.34,40.26 188,38.61 188,33.05 186.24,31.3 186.24,30.41 v6(186.79,29.86)
  BOTTOM w0.127: v6(186.79,29.86) 186.52,29.6 186.52,28.53 186.41,28.42 184.89,28.42 183.6,29.7 183.6,38.18 183.22,38.56 183.22,40.12 182.4,40.93 RP34.1 ; v2(77.15,57.1) 77.15,57 76.85,56.7 U16.J3
UART1_RTS_R: length 4.1
  TOP w0.127: U13.4 181.83,28.73 v6(181.72,28.62) 181.08,29.25 R186.1
  BOTTOM w0.127: v6(181.72,28.62) 181.68,28.65 CN4.36
UART1_RX: length 151.1
  TOP w0.127: v6(185.81,29.04) 185.72,29.13 U13.9
  IN4 w0.089: v6(185.81,29.04) 185.81,31.37 187.64,33.2 187.64,38.33 186.9,39.07 186.27,39.07 185.43,39.91 182.64,39.91 181.85,39.12 173.54,39.12 168.74,43.92 168.74,49.51 167.56,50.69 161.77,50.69 160,52.46 154.87,52.46 154.06,53.27 134.46,53.27 134.22,53.02 121.35,53.02 121.07,52.74 118.88,52.74 118.35,53.27 114.74,53.27 114.41,52.94 105.95,52.94 105.4,53.49 89.38,53.49 87.86,55.01 81.07,55.01 79.46,56.62 79.46,56.88 79.16,57.18 78.06,57.18 77.71,56.82 76.62,56.82 76.34,57.1 v2(76.29,57.1)
  BOTTOM w0.127: v6(185.81,29.04) 185.81,29.72 186.87,30.78 186.93,30.78 187.2,31.04 187.2,37.28 184.05,40.43 RP33.1 ; v2(76.29,57.1) 76.39,57 76.39,56.49 76.06,56.17 U16.K4
UART1_RX_R: length 6.6
  TOP w0.127: R184.1 181.05,30.27 181.32,30 v6(181.92,30) 181.92,29.76 182.55,29.13 U13.3
  BOTTOM w0.127: v6(181.92,30) 182.2,30.28 182.2,31.2 181.25,32.15 CN4.22
UART1_TX: length 148.9
  TOP w0.127: U13.10 185.61,29.53 186.19,30.1 186.19,30.66 v6(186.75,31.22)
  IN4 w0.089: v6(186.75,31.22) 188.38,32.85 188.38,38.74 186.47,40.64 182.33,40.64 181.54,39.86 173.78,39.86 170.11,43.53 170.11,43.55 169.43,44.22 169.43,49.82 167.48,51.77 161.71,51.77 160.28,53.19 155.51,53.19 154.62,54.08 134,54.08 133.63,53.71 129.46,53.71 128.97,54.21 128.21,54.21 127.74,53.75 121.66,53.75 121.15,54.25 119.44,54.25 119.19,54 114.46,54 114.08,53.62 106.31,53.62 105.54,54.39 99.54,54.39 99.22,54.72 95.64,54.72 95.46,54.53 89.37,54.53 88.21,55.69 86.63,55.69 85.96,56.35 84.6,56.35 84.25,56.7 80.4,56.7 79.41,57.69 77.3,57.69 v2(76.72,57.1)
  BOTTOM w0.127: v6(186.75,31.22) 186.81,31.28 186.81,37.13 183.4,40.54 RP33.3 ; v2(76.72,57.1) 76.74,57.1 77.13,57.49 U16.G2
UART1_TX_R: length 6.2
  TOP w0.127: U13.2 182.71,29.53 182.56,29.67 182.56,30.15 182.25,30.46 181.51,30.46 v6(181.35,30.62) 180.86,31.11 v7(180.86,31.25) 180.86,32.01 R173.1
  BOTTOM w0.127: CN4.32 181.23,29.65 181.35,29.77 v6(181.35,30.62)
USB2_CAM_PWR_EN: length 133.7
  TOP w0.127: v4(180.55,41.48) 184.57,41.48 185.57,40.49 185.57,39.39 186.06,38.89 v7(187.39,38.89) 190.29,38.89 PR70.2
  IN1 w0.089: v4(180.55,41.48) 180.35,41.48 v5(180.05,41.18)
  IN3 w0.089: v2(76.51,53.37) 76.62,53.47 76.9,53.47 77.91,54.49 77.91,54.74 78.42,55.25 79.51,55.25 79.92,54.84 83.5,54.84 84.39,55.73 v2(84.57,55.73) 84.58,55.72 84.58,55.54 85.77,54.35 86,54.35 87.4,52.96 89.58,52.96 90.66,51.87 90.66,51.82 91.25,51.24 103.51,51.24 104.84,49.92 111.41,49.92 115.71,45.62 131.23,45.62 132.55,44.3 134.56,44.3 135.22,44.96 135.22,45.71 135.96,46.45 137.84,46.45 139.09,45.2 141.04,45.2 144.52,48.68 151.98,48.68 152.46,49.15 162.21,49.15 163.99,47.38 163.99,46.33 164.58,45.75 164.58,45.75 169.25,41.08 178.8,41.08 179.02,41.3 179.92,41.3 v5(180.05,41.18)
  BOTTOM w0.127: v2(84.57,55.73) 84.57,55.5 84.69,55.38 R280.1 ; v2(76.51,53.37) 76.71,53.57 U16.P3
USB2_CAM_PWR_EN_R: length 4.3
  TOP w0.127: v7(193.28,42.32) 192.7,41.75 PR70.1 PR69.1 191.35,42.1 190.73,42.72 PU5.5
USB3.0_RX1+: length 177.2
  IN4 w0.089: v2(66.84,57.14) 66.84,57.31 66.99,57.46 67.13,57.46 67.49,57.1 67.85,57.1 68.06,56.89 68.06,56.31 70.65,53.72 70.65,50.9 72.45,49.1 75.48,49.1 75.86,49.48 76.28,49.48 76.51,49.26 78.43,49.26 78.78,49.61 85.07,49.61 85.78,48.9 102.27,48.9 102.8,48.37 112.84,48.37 114.26,46.94 138.75,46.94 139.04,47.24 155.49,47.24 155.83,46.89 157.38,46.89 159.54,44.73 161.5,44.73 163.3,42.93 164.64,42.93 171.82,35.76 171.82,30.62 170.19,28.99 170.19,27.17 170.75,26.61 171.69,26.61 173.15,25.15 174.74,25.15 175.9,23.99 182.91,23.99 185.38,26.47 186.28,26.47 187.23,27.43 187.23,28.57 188.02,29.36 188.02,30.86 189.53,32.37 189.6,32.43 189.6,39.09 194.31,43.8 194.31,46.32 195.51,47.52 197.17,47.52 197.67,47.02 199.64,47.02 v2(199.77,46.9)
  BOTTOM w0.114: v2(199.77,46.9) 199.93,47.06 200.38,47.06 v7(200.9,46.55) 201.41,47.06 201.85,47.06 R334.1
USB3.0_RX1+_R: length 10.4
  IN4 w0.089: v2(206.48,46.68) 206.48,46.84 206.55,46.91 207.19,46.91 207.82,47.54 207.82,48.33 209.4,49.9 210.09,49.9 210.2,49.8 CN2.6
  BOTTOM w0.114: R334.2 203.44,47.1 203.72,47.1 203.97,46.84 204.28,46.84 204.44,46.68 EU1.4 EU1.7 205.84,46.68 205.97,46.82 206.35,46.82 v2(206.48,46.68)
USB3.0_RX1-: length 177.2
  IN4 w0.089: v2(66.84,57.79) 66.97,57.66 67.22,57.66 67.57,57.31 67.93,57.31 68.26,56.98 68.26,56.39 70.85,53.8 70.85,50.98 72.53,49.31 75.4,49.31 75.78,49.69 76.36,49.69 76.59,49.46 78.34,49.46 78.7,49.81 85.15,49.81 85.86,49.1 102.35,49.1 102.89,48.57 112.92,48.57 114.34,47.15 138.67,47.15 138.96,47.44 155.57,47.44 155.92,47.09 157.47,47.09 159.62,44.94 161.58,44.94 163.39,43.13 164.73,43.13 172.02,35.84 172.02,30.54 170.39,28.91 170.39,27.26 170.84,26.81 171.78,26.81 173.24,25.35 174.83,25.35 175.98,24.2 182.82,24.2 185.3,26.67 186.19,26.67 187.03,27.51 187.03,28.66 187.82,29.44 187.82,30.94 189.33,32.45 189.33,32.45 189.39,32.52 189.39,39.17 194.1,43.89 194.1,46.4 195.42,47.72 197.26,47.72 197.75,47.22 199.63,47.22 199.77,47.36 v2(199.77,47.45)
  BOTTOM w0.114: v2(199.77,47.45) 199.95,47.27 200.35,47.27 v7(200.9,47.82) 201.45,47.27 201.81,47.27 R335.1
USB3.0_RX1-_R: length 10.4
  IN4 w0.089: v2(206.48,47.18) 206.55,47.11 207.1,47.11 207.62,47.62 207.62,48.41 209.31,50.11 210.09,50.11 210.2,50.21 CN2.5
  BOTTOM w0.114: v2(206.48,47.18) 206.32,47.02 205.95,47.02 205.79,47.18 EU1.6 EU1.5 204.41,47.18 204.28,47.05 204.06,47.05 203.8,47.3 203.41,47.3 R335.2
USB3.0_RX2+: length 74
  IN4 w0.114: v2(68.18,58.45) 67.83,58.8 67.83,59.24 67.88,59.29 67.88,59.79 66.75,60.93 65.7,60.93 64.62,62.01 57.67,62.01 57.4,62.27 54.91,62.27 54.44,61.8 53.66,61.8 52.56,60.71 52.56,60.46 51.41,59.3 47.32,59.3 47.19,59.18 44.1,59.18 42.48,57.56 42.48,55.87 41.94,55.33 41.46,55.33 41.08,54.94 38.72,54.94 36.51,52.73 33.36,52.73 32.72,52.09 28.5,52.09 27.45,51.05 26.8,51.05 16.66,40.91 11.86,40.91 10.63,39.68 10.63,38.36 10.75,38.23 v2(11.02,38.23)
  BOTTOM w0.127: CN3.30 10.9,37.68 10.78,37.8 10.78,37.99 v2(11.02,38.23) ; U16.F18 v2(68.18,58.45)
USB3.0_RX2-: length 74.1
  IN4 w0.114: v2(10.22,38.23) 10.28,38.3 10.28,39.82 11.72,41.25 16.52,41.25 26.65,51.39 27.31,51.39 28.36,52.44 32.58,52.44 33.22,53.08 36.37,53.08 38.58,55.29 40.94,55.29 41.32,55.67 41.8,55.67 42.14,56.01 42.14,57.71 43.96,59.52 47.05,59.52 47.18,59.64 51.26,59.64 52.22,60.6 52.22,60.85 53.52,62.15 54.3,62.15 54.77,62.62 57.54,62.62 57.81,62.35 64.77,62.35 65.85,61.27 66.89,61.27 68.22,59.94 68.22,59.13 v2(68.18,59.1)
  BOTTOM w0.127: U16.E18 v2(68.18,59.1) ; v2(10.22,38.23) 10.51,37.94 10.51,37.79 10.4,37.67 CN3.29
USB3.0_TX1+: length 187.3
  IN4 w0.089: v2(196.94,45.9) 197.06,46.03 197.06,46.21 196.97,46.3 196.01,46.3 195.45,45.73 195.45,43.36 190.88,38.79 190.88,36.66 191.2,36.34 191.2,31.75 189.49,30.05 189.49,26.98 187.06,24.54 184.9,24.54 184.82,24.54 182.25,21.98 177.35,21.98 176.35,22.98 173.27,22.98 171.2,25.05 170.94,25.05 169.12,26.87 169.12,33.67 169.66,34.2 169.66,36.22 164.62,41.25 162.67,41.25 162.3,41.62 161.03,41.62 157.02,45.62 155.48,45.62 155.02,46.08 141.41,46.08 141.27,45.93 113.79,45.93 112.32,47.4 102.24,47.4 101.61,48.04 84.95,48.04 84.25,48.73 79.32,48.73 78.72,48.14 73.67,48.14 73.24,48.57 71.64,48.57 69.76,50.45 69.76,53.29 66.76,56.29 66.09,56.29 65.64,56.74 65.64,58.09 64.68,59.05 58.3,59.05 57.59,59.76 57.59,60.39 57.72,60.52 v2(57.72,60.74)
  BOTTOM w0.114: C255.1 197.63,43.32 197.5,43.32 197.11,43.7 197.11,45.72 v2(196.94,45.9)
USB3.0_TX1+_C: length 1.8
  BOTTOM w0.114: C255.2 199.22,43.25 199.99,43.25 R321.1
USB3.0_TX1+_R: length 13.4
  IN4 w0.089: CN2.9 210.2,43.08 210.02,43.26 209.17,43.26 207.11,45.32 206.62,45.32 206.55,45.25 206.55,45.25 v2(206.48,45.18)
  BOTTOM w0.114: v2(206.48,45.18) 206.36,45.3 205.93,45.3 205.82,45.18 EU1.10 EU1.1 204.42,45.18 204.24,45.36 204.1,45.36 203.94,45.2 203.94,44.26 203.73,44.05 203.49,44.05 C254.1 202.44,44.02 202.28,44.02 202.2,43.94 202.2,43.51 201.95,43.27 201.52,43.27 R321.2
USB3.0_TX1-: length 187.3
  IN4 w0.089: v2(58.29,60.41) 58.17,60.53 58.02,60.53 57.79,60.3 57.79,59.85 58.39,59.26 64.76,59.26 65.85,58.17 65.85,56.82 66.18,56.49 66.68,56.49 66.85,56.49 69.96,53.38 69.96,50.53 71.72,48.77 73.32,48.77 73.75,48.34 78.64,48.34 79.24,48.94 84.33,48.94 85.03,48.24 101.69,48.24 102.33,47.6 112.4,47.6 113.87,46.14 141.18,46.14 141.33,46.28 155.1,46.28 155.56,45.83 156.94,45.83 157.11,45.83 161.11,41.83 162.39,41.83 162.76,41.46 164.7,41.46 169.86,36.3 169.86,34.12 169.33,33.58 169.33,26.95 171.03,25.25 171.12,25.25 171.28,25.25 173.35,23.18 176.27,23.18 176.27,23.18 176.31,23.18 176.31,23.18 176.43,23.18 177.44,22.18 182.17,22.18 184.74,24.74 184.99,24.74 186.97,24.74 189.29,27.06 189.29,29.97 189.29,30.13 190.99,31.84 190.99,36.25 190.68,36.57 190.68,38.87 195.25,43.45 195.25,45.82 195.93,46.5 197.06,46.5 197.27,46.29 197.27,46.03 197.39,45.9 v2(197.55,45.9)
  BOTTOM w0.114: C256.1 197.7,43.52 197.58,43.52 197.32,43.79 197.32,45.78 197.44,45.9 v2(197.55,45.9)
USB3.0_TX1-_C: length 1.8
  BOTTOM w0.114: C256.2 199.23,43.51 199.98,43.51 R327.1
USB3.0_TX1-_R: length 13.3
  IN4 w0.089: v2(206.48,45.68) 206.64,45.52 207.2,45.52 209.26,43.46 209.99,43.46 210.2,43.67 CN2.8
  BOTTOM w0.114: v2(206.48,45.68) 206.3,45.5 205.93,45.5 205.75,45.68 EU1.9 EU1.2 204.36,45.68 204.24,45.57 204.02,45.57 203.74,45.28 203.74,44.35 203.64,44.25 203.47,44.25 C257.1 202.42,44.23 202.19,44.23 202,44.03 202,43.6 201.87,43.47 201.56,43.47 R327.2
USB3.0_TX2+: length 61.4
  IN4 w0.114: v2(58.29,61.71) 58.29,61.62 58.23,61.56 57.35,61.56 57.02,61.89 55.14,61.89 54.66,61.41 54.02,61.41 53.29,60.68 53.29,60.07 51.78,58.55 44.38,58.55 42.75,56.93 42.75,54.73 42.22,54.2 41.22,54.2 41.04,54.02 39.59,54.02 37.65,52.07 33.61,52.07 33.01,51.47 28.77,51.47 17.04,39.74 14.04,39.74 13.43,39.13 13.43,37.91 13.08,37.56 12.47,37.56 12.2,37.83 12.2,38.16 12.31,38.26 v2(12.52,38.26)
  BOTTOM w0.127: v2(12.52,38.26) 12.31,38.26 12.2,38.16 12.2,37.88 12.4,37.68 CN3.33
USB3.0_TX2-: length 61.4
  IN4 w0.114: v2(58.29,61.06) 58.13,61.22 57.21,61.22 56.88,61.55 55.28,61.55 54.8,61.07 54.16,61.07 53.63,60.53 53.63,59.92 51.92,58.21 44.52,58.21 43.09,56.78 43.09,54.59 42.36,53.85 41.36,53.85 41.18,53.67 39.73,53.67 37.79,51.73 33.75,51.73 33.15,51.13 28.91,51.13 17.18,39.4 14.18,39.4 13.77,38.99 13.77,37.77 13.22,37.22 12.33,37.22 11.86,37.69 11.86,38.23 v2(11.83,38.26)
  BOTTOM w0.127: CN3.32 11.9,37.74 11.94,37.77 11.94,38.16 v2(11.83,38.26)
USB3_P0_EN: length 8
  TOP w0.127: v6(78.83,40.95) 78.78,40.9 78.78,39.68 77.76,38.66 v7(76.95,38.66) 76.68,38.93 R157.1 R156.1
  BOTTOM w0.089: U16.AT3 77.04,41.39 78.34,41.39
  BOTTOM w0.127: 78.34,41.39 78.39,41.39 v6(78.83,40.95)
USB3_P0_EN_EC: length 74.9
  TOP w0.127: v4(194.9,41.74) v7(195.92,41.74) 198.07,41.74 C130.2 199.06,42.72 U7.5 ; U4.A13 141.05,59.98 142.37,61.29 v9(142.67,61.29)
  IN1 w0.089: v4(194.9,41.74) 194.68,41.74 189.27,47.15 v9(189.27,55.48)
  IN2 w0.089: v9(142.67,61.29) 142.71,61.26 145.18,61.26 146.23,60.22 146.23,59.48 148.7,57 158.2,57 158.86,57.66 170.88,57.66 171.26,58.04 174.13,58.04 175.3,56.88 175.8,56.88 177.01,55.67 181.18,55.67 182.23,56.72 188.02,56.72 v9(189.27,55.48)
USB3_P1_EN: length 16.9
  IN4 w0.089: v2(78.62,38.82) 79.04,38.39 80.64,38.39 81.75,37.29 87.59,37.29 v2(87.97,37.67)
  BOTTOM w0.089: U16.AV3 77.02,40.08 77.02,39.4 77.07,39.35 77.07,38.87 77.25,38.69
  BOTTOM w0.127: R350.1 R351.1 88.86,38.31 88.61,38.56 TP123.1 v2(87.97,37.67) ; 77.25,38.69 77.34,38.6 78.41,38.6 v2(78.62,38.82)
USB3_P1_EN_EC: length 166.4
  TOP w0.127: v6(13.9,34.75) 13.83,34.68 v7(13.83,33.99) ; U4.M2 v4(135.26,54.23)
  IN1 w0.089: v9(134.81,53.44) 134.95,53.58 134.95,53.92 v4(135.26,54.23)
  IN2 w0.089: v5(58.02,67.34) 58.02,65.54 59.34,64.22 63.21,64.22 64.63,65.64 70.77,65.64 72.1,66.96 86.78,66.96 87.51,66.22 92.47,66.22 93.3,67.06 102.78,67.06 104.33,65.51 104.33,59.47 105.57,58.22 106.82,58.22 107.86,57.18 113.45,57.18 115.5,55.12 126.4,55.12 128.13,53.4 129.85,53.4 130.9,52.35 131.86,52.35 132.04,52.18 133,52.18 134.26,53.44 v9(134.81,53.44)
  IN3 w0.089: v6(13.9,34.75) 14.36,35.21 14.36,43.64 15.15,44.43 19.9,44.43 21.16,45.69 21.16,50.79 21.98,51.62 23.86,51.62 24.95,52.71 28.2,52.71 31.2,55.71 37.47,55.71 39.84,58.07 40.62,58.07 40.72,57.97 41.46,57.97 42.5,59.01 42.5,60.08 41.28,61.29 41.28,65.38 43.62,67.72 57.64,67.72 v5(58.02,67.34)
  BOTTOM w0.127: v6(13.9,34.75) 14.4,34.26 CN3.18
USB_BIAS: length 3.9
  TOP w0.127: R126.1 72.92,44.79 v6(72.78,44.66)
  IN1 w0.127: v4(73.6,44.69) 73.39,44.9 v5(73.39,44.99)
  IN4 w0.127: v5(73.39,44.99) 73.19,44.77 v2(73.19,44.63)
  BOTTOM w0.127: U16.AJ11 71.61,45.65 72.3,45.65 U16.AJ10 72.36,45.56 73.19,44.74 v2(73.19,44.63)
USB_BUS_SW0_CT1: length 84.7
  TOP w0.127: U4.A8 138.51,60.5 v9(138.97,60.96) ; U7.6 199.56,42.66 199.1,42.19 C131.2 198.85,41.75 198.59,41.48 198.59,39.35 198.46,39.22 v7(196.33,39.22) 195.13,39.22 v4(194.78,39.58)
  IN1 w0.089: v4(194.78,39.58) 194.73,39.58 193.57,40.73 191.34,40.73 189.34,42.73 189.34,43.26 186.55,46.05 186.55,55.15 183.65,58.04 180.05,58.04 178.8,56.8 v9(178.8,55.2)
  IN2 w0.089: v9(178.8,55.2) 176.92,55.2 175.65,56.47 174.99,56.47 173.82,57.64 171.41,57.64 171.03,57.26 159.34,57.26 158.51,56.42 148.42,56.42 144.59,60.25 139.3,60.25 138.97,60.58 v9(138.97,60.96)
USB_BUS_SW1_CT1: length 145.3
  TOP w0.127: v9(134.03,53.66) 134.35,53.98 U4.N1
  IN1 w0.089: v9(108.16,58.37) 107.88,58.09 105.85,58.09 105.55,58.4 104.23,58.4 103.9,58.73 87.56,58.73 87.28,59.01 82.4,59.01 82.26,58.86 80.72,58.86 79.36,60.23 78.87,60.23 76.54,62.56 74.36,62.56 74.25,62.46 72.68,62.46 72.3,62.08 69.73,62.08 68.64,60.99 66.58,60.99 64.93,59.34 57.68,59.34 57.57,59.46 44.01,59.46 42.46,57.91 38.71,57.91 37.08,56.28 37.08,49.55 29.94,42.42 22.33,42.42 19.82,39.91 19.82,38.36 18.73,37.27 15.64,37.27 v6(13.9,35.53)
  IN2 w0.089: v9(134.03,53.66) 133.41,53.04 132.06,53.04 131.73,52.71 131,52.71 128.81,54.89 128.31,54.89 126.4,56.8 117.74,56.8 117.26,56.32 115.07,56.32 113.52,57.87 108.67,57.87 v9(108.16,58.37)
  BOTTOM w0.127: v6(13.9,35.53) 13.45,35.07 13.45,34.55 13.9,34.1 CN3.19
USB_CHG_DET0#: length 119.7
  TOP w0.127: v9(118.7,58.75) 119.06,58.4 v7(119.06,58.07) 119.21,57.92 D7.3
  IN2 w0.089: v9(118.7,58.75) 119.01,58.75 122.54,62.29 122.54,62.92 125.23,65.61 131.91,65.61 132.87,66.58 138.61,66.58 138.77,66.73 151.03,66.73 154.92,62.84 165.52,62.84 168.23,65.56 173.95,65.56 174.63,64.88 186.88,64.88 188.3,63.45 188.3,62.51 189.62,61.19 195.77,61.19 198.43,63.86 202.8,63.86 204.37,65.43 206.62,65.43 208.08,63.97 208.08,51.19 208.92,50.35 210.42,50.35 CN2.10
USB_CHG_DET0#_R: length 21.9
  TOP w0.127: U4.M1 133.91,54.48 133.56,54.13 133.56,52.79 132.5,51.72 131.45,51.72 130.92,51.19 130.62,51.19 v6(130.24,51.57) 130.03,51.77 v9(126.68,51.77) ; D7.2 118.55,53.32 v9(118.58,53.29) 118.45,53.17 R89.2
  IN2 w0.089: v9(118.58,53.29) 119.16,52.71 123,52.71 123.48,52.23 126.22,52.23 v9(126.68,51.77)
USB_CHG_DET1#: length 132.2
  IN1 w0.089: v6(17.1,35.46) 17.1,35.67 17.89,36.45 19.24,36.45 20.56,37.77 20.56,39.86 22.72,42.02 30.41,42.02 37.68,49.29 37.68,55.91 39.27,57.5 42.59,57.5 44.17,59.08 57.3,59.08 57.52,58.86 65.24,58.86 66.56,60.18 68.72,60.18 70,61.46 72.36,61.46 72.43,61.53 72.53,61.53 72.82,61.82 73.46,61.82 73.59,61.69 76.01,61.69 76.54,61.16 76.54,60.28 79.48,57.33 82.97,57.33 83.44,57.8 90.89,57.8 91.35,58.26 103.5,58.26 103.97,57.79 105.47,57.79 105.55,57.87 108.59,57.87 109.41,58.68 v9(110.73,58.68)
  IN2 w0.089: v9(110.73,58.68) 110.88,58.53 113.52,58.53 114.84,57.21 124.78,57.21 125.67,58.09 v9(125.71,58.09)
  BOTTOM w0.127: v6(17.1,35.46) 17.1,34.88 16.52,34.29 16.16,34.29 15.9,34.03 CN3.15
USB_CHG_DET1#_R: length 14.6
  TOP w0.127: v7(124.8,53.42) 124.92,53.54 v4(124.92,54.31) 124.92,54.87 125.1,55.06 D5.2
  IN1 w0.089: v4(124.92,54.31) 124.92,54.53 127.89,57.5 135.49,57.5 v4(135.51,57.48)
USB_OC0#: length 140.9
  TOP w0.127: R119.1 82.5,45.31 ; 82.5,45.31 R121.1 v4(82.48,45.29) ; 82.5,45.31 v4(82.48,45.29) ; v4(82.48,45.29) 81.52,45.29 TP32.1 ; U7.13 200.56,47.45 201,47.9 R106.2 200.79,48.33 v9(200.39,47.93)
  IN1 w0.089: v4(82.48,45.29) 81.95,45.29 v5(81.72,45.06)
  IN2 w0.089: v9(200.39,47.93) 200.14,48.19 199.29,48.19 199.05,47.95 199.05,47.92 197.95,46.82 195.41,46.82 192.87,44.28 191.22,44.28 189.32,42.37 182.08,42.37 180.53,40.82 160.26,40.82 159.5,41.58 155.41,41.58 155.15,41.84 146.64,41.84 144.03,39.22 141.89,39.22 141.54,38.87 136.92,38.87 136.43,39.35 132.98,39.35 132.33,38.7 123.37,38.7 123.05,39.02 117.94,39.02 117.84,38.92 106.69,38.92 105.93,39.68 105.93,40.19 103.03,43.08 97.19,43.08 95.67,41.56 91.98,41.56 90.84,40.42 88.48,40.42 85.15,43.74 85.15,44.45 84.54,45.06 v5(81.72,45.06)
  IN3 w0.089: v2(76.76,44.99) 76.76,45.14 77.07,45.45 78.42,45.45 78.5,45.37 79.31,45.37 79.44,45.5 81.29,45.5 v5(81.72,45.06)
  BOTTOM w0.127: v2(76.76,44.99) 76.76,44.77 U16.AL3
