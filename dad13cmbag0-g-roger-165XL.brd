# Allegro board dad13cmbag0-g-roger-165XL.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
+V3.3DX_NGFF_WLAN_R on TOP (solid shape): 169.83,42.27 169.83,38.71 169.58,38.46 167.47,38.46 167.42,38.51 167.42,39.2 167.4,39.22 167.22,39.22 167.19,39.2 167.19,38.51 167.14,38.46 167.07,38.46 167.01,38.51 167.01,39.5 167.32,39.81 167.32,40.64 167.47,40.8 168.13,40.8 168.31,40.97 168.31,42.22 168.44,42.35 169.76,42.35
+V3.3DX_SSD on TOP (solid shape): 162.49,42.93 164.12,42.93 164.68,42.37 164.68,41.99 163.95,41.27 163.95,40.76 163.81,40.62 162.29,40.62 161.76,40.09 161.76,39.7 161.63,39.58 160.49,39.58 160.23,39.32 160.23,38.44 160.87,37.8 160.87,37.29 161.12,37.04 161.76,37.04 161.88,36.91 161.88,36.35 161.68,36.15 159.73,36.15 159.09,36.78 159.09,41.99 160.13,43.03 162.39,43.03
+V3.3DX_SSD on BOTTOM (solid shape): 160.7,49.11 161.85,49.11 162.03,48.93 162.03,48.04 161.72,47.74 160.14,47.74 160.07,47.8 158.02,47.8 158.02,48.3 160.17,48.3 160.44,48.57 160.44,48.86 160.7,49.12
+V3.3DX_SSD on BOTTOM (solid shape): 162.42,60.07 162.42,59.16 162.11,58.86 161.12,58.86 160.16,59.82 158.05,59.82 158.05,60.3 160.06,60.3 160.13,60.38 160.13,60.63 159.78,60.99 159.78,61.19 159.88,61.29 161.19,61.29
+V3.3DX_SSD on BOTTOM (solid shape): 165.72,42.3 170.18,42.3 170.22,42.25 170.22,41.13 170.1,41 165.8,41 165.08,40.28 165.08,39.92 163.5,38.34 161.91,38.34 161.22,37.65 161.22,36.33 161,36.1 160.61,36.1 160.11,36.61 158.02,36.61 158.02,37.09 160.02,37.09 160.02,37.09 160.11,37.09 160.21,37.19 160.21,38.33 160.62,38.75 160.68,38.74 160.73,38.74 160.79,38.75 160.85,38.76 160.9,38.78 160.94,38.81 160.99,38.85 161.02,38.9 161.05,38.94 161.08,39 161.09,39.04 161.99,39.93 161.99,41.48 168.26,41.48 168.26,41.81 166.18,41.81 166.18,41.48 161.99,41.48 161.99,42.98 162.24,43.24 164.78,43.24
+V3.3DX_SSD_R on TOP (solid shape): 165.14,40.57 165.14,39.93 165.59,39.48 165.59,38.49 165.54,38.43 165.49,38.43 165.41,38.51 165.41,39.2 165.39,39.22 165.21,39.22 165.19,39.2 165.19,38.51 165.11,38.43 164.81,38.43 164.12,37.75 162.98,37.75 162.24,38.49 162.24,39.98 162.31,40.05 163.83,40.05 164.47,40.7 165.01,40.7
+V3.3DX_TCH_PAD on TOP (solid shape): 155.84,21.67 155.84,21.04 155.94,20.93 157.74,20.93 157.87,20.81 157.87,19.44 157.77,19.33 155.2,19.33 155.03,19.51 155.03,21.62 155.1,21.7 155.81,21.7
+V3.3DX_TCH_PAD on BOTTOM (solid shape): 158.2,20.15 158.96,20.15 159.09,20.02 159.09,18.24 157.31,16.46 157.31,14.3 157.69,13.92 159.85,13.92 160.36,13.42 160.36,9.61 160.11,9.35 156.42,9.35 156.3,9.48 156.3,20.4 156.68,20.78 157.57,20.78
+V3.3DX_TCH_PAD_R on TOP (solid shape): 189.37,24.85 189.77,24.85 190,25.07 190,25.39 190.05,25.44 190.21,25.44 190.21,24.69 190.41,24.69 190.41,25.44 190.57,25.44 190.6,25.42 190.6,24 190.48,23.73 190.6,23.46 190.6,23.33 190.21,22.94 189.82,22.94 189.15,23.61 187.83,23.61 187.7,23.74 187.7,25.62 188,25.91 188.3,25.91
+V3.3DX_TCH_SCR_R on TOP (solid shape): 189.29,47.72 189.29,46.64 189.62,46.31 189.62,45.34 189.57,45.29 189.49,45.29 189.44,45.34 189.44,46.08 189.42,46.11 189.24,46.11 189.21,46.08 189.21,45.32 189.16,45.27 187.69,45.27 187.56,45.39 187.56,47.85 187.64,47.93 189.09,47.93
+V3.3S_1.8S_LPSS_SDIO on TOP (solid shape): 75.66,54.63 75.66,53.99 75.32,53.65 74.69,53.65 74.46,53.87 74.46,54.59 74.6,54.73 75.56,54.73
+V3.3S_1.8S_LPSS_SDIO on BOTTOM (solid shape): 93.71,58.53 93.71,58.32 93.38,57.99 92.83,57.99 92.69,57.85 92.25,57.85 92.19,57.92 92.19,58.53 92.26,58.6 93.63,58.6
+V3.3S_1.8S_LPSS_SDIO on IN1 (solid shape): 79.89,59.29 79.89,58.75 79.75,58.62 79.27,58.62 78.72,59.16 78.72,59.54 78.93,59.75 79.44,59.75
+V3.3S_1.8S_LPSS_SDIO on IN1 (solid shape): 75.14,53.88 75.14,53.8 74.37,53.02 73.63,53.02 73.52,53.13 73.52,53.35 74.18,54 75.02,54
+V5DX_AUDIO on TOP (solid shape): 91.45,27.79 92.64,27.79 92.64,26.33 92.42,26.12 90.26,26.12 88.02,28.35 88.02,29.57 88.33,29.87 89.37,29.87
+V5DX_AUDIO on TOP (solid shape): 25.38,39.19 25.43,39.17 25.49,39.17 25.54,39.17 25.59,39.19 25.63,39.2 25.77,39.2 27.26,37.7 27.26,35.01 26.88,34.62 23.5,34.62 22.62,35.51 22.62,36.54 23.22,36.54 23.22,36.46 23.23,36.39 23.24,36.31 23.27,36.24 23.3,36.17 23.34,36.1 23.38,36.04 23.43,35.98 23.49,35.93 23.55,35.89 23.62,35.85 23.69,35.82 23.76,35.79 23.84,35.78 23.91,35.77 23.99,35.77 24.06,35.78 24.14,35.79 24.21,35.82 24.28,35.85 24.35,35.89 24.41,35.93 24.47,35.98 24.52,36.04 24.56,36.1 24.6,36.17 24.63,36.24 24.66,36.31 24.67,36.39 24.68,36.46 24.68,36.54 24.67,36.61 24.66,36.69 24.63,36.76 24.6,36.83 24.56,36.9 24.52,36.96 24.47,37.02 24.41,37.07 24.35,37.11 24.28,37.15 24.21,37.18 24.14,37.21 24.06,37.22 23.99,37.23 23.91,37.23 23.84,37.22 23.76,37.21 23.69,37.18 23.62,37.15 23.55,37.11 23.49,37.07 23.43,37.02 23.38,36.96 23.34,36.9 23.3,36.83 23.27,36.76 23.24,36.69 23.23,36.61 23.22,36.54 22.62,36.54 22.62,38.25 23.56,39.2 25.34,39.2
+V5DX_AUDIO on BOTTOM (solid shape): 24.6,38.69 24.6,37.93 23.96,37.29 23.58,37.29 23.2,36.91 23.2,35.89 22.95,35.64 21.62,35.64 21.27,35.99 21.27,36 22.75,36 22.75,37.6 22.55,37.6 22.55,36 21.27,36 21.27,36 21.75,36 21.75,36 22.25,36 22.25,37.6 22.05,37.6 22.05,36 21.75,36 21.75,37.6 21.55,37.6 21.55,36 21.27,36 21.27,37.63 21.43,37.79 21.43,38.9 21.6,39.07 24.22,39.07
+VCCIN on TOP (solid shape): 32.12,50.19 33.87,50.19 34.1,49.97 34.1,48.57 33.79,48.26 33,48.26 30.29,45.55 29.5,45.55 29.22,45.83 29.22,47.81 28.92,48.11 28.48,48.11 28.15,48.44 28.15,48.95 27.95,49.15 27.95,50.19 28.25,50.5 31.81,50.5
+VCCIN on TOP (solid shape): 63.46,58.98 63.46,58.09 63.71,57.84 64.25,57.84 64.73,57.36 64.73,56.85 65.16,56.42 65.54,56.42 65.75,56.21 65.75,55.25 65.44,54.94 64.6,54.94 64.48,54.82 64.09,54.82 62.19,56.72 45.17,56.72 44.31,55.86 44.31,45.78 43.55,45.02 41.15,45.02 41.08,45.09 41.08,46.05 42.05,47.02 42.05,57.74 42.31,58.01 42.3,58.02 42.3,59.14 42.33,59.16 42.48,59.16 42.5,59.19 49.9,59.19 50.07,59.36 63.08,59.36
+VCCIN on BOTTOM (solid shape): 31.86,49.97 31.86,46.97 31.44,46.55 31.44,45.99 30.39,44.94 27.14,44.94 26.93,44.73 26.93,43.95 26.78,43.79 26.12,43.79 26.04,43.87 26.04,44.58 25.77,44.86 18.09,44.86 17.89,45.06 17.89,47.02 18.04,47.17 19.63,47.17 19.66,47.2 19.66,47.68 19.61,47.73 18.05,47.73 17.89,47.88 17.89,49.05 18.3,49.46 20.46,49.46 21.04,48.87 26.53,48.87 28.15,50.5 31.33,50.5
+VCCIN on BOTTOM (solid shape): outline of 1836 points within 41.64,46.73 65.69,59.87
+VCCIN on IN2 (solid shape): outline of 1220 points within 27.9,44.91 64.36,58.13
+VCCIN on SVCC (solid shape): outline of 155 points within 18.12,38.56 64.35,61.29
AGND_LB on BOTTOM (solid shape): 182.48,67.52 182.57,67.47 182.57,67.36 182.89,66.78 183.21,67.36 183.21,67.47 183.3,67.52 183.7,67.52 184.95,66.27 189.09,66.27 189.77,65.59 189.77,64.11 189.49,63.83 188.35,63.83 187.92,63.4 187.92,62.89 187.72,62.69 187.69,62.69 187.49,62.49 187.49,61.93 187.21,61.65 184.85,61.65 184.69,61.5 184.69,60.79 184.74,60.74 187.64,60.74 187.77,60.61 187.77,59.42 187.64,59.29 183.47,59.29 183.27,59.49 183.27,62.51 183.4,62.64 183.4,63.83 182.08,65.16 180.22,65.16 179.94,65.43 179.94,67.34 180.12,67.52
GND on TOP (solid shape): 62.86,64.62 59.22,64.62 59.22,67.47 62.86,67.47
GND on TOP (solid shape): 20.1,17.7 20.1,16.89 20.04,16.83 18.05,16.83 17.86,17.03 17.86,17.94 18.05,18.13 19.66,18.13
GND on TOP (solid shape): 36.69,50.09 36.69,48.57 36.56,48.44 34.73,48.44 34.71,48.47 34.71,50.04 34.93,50.27 36.51,50.27
GND on TOP (solid shape): 45.93,17.86 45.93,16.84 45.81,16.72 45.17,16.72 45.04,16.84 45.04,17.86 45.17,17.99 45.81,17.99
GND on TOP (solid shape): 53.53,18.1 53.53,17.61 53.41,17.48 52.39,17.48 52.27,17.61 52.27,18.17 52.39,18.29 53.34,18.29
GND on TOP (solid shape): 96.83,28.99 96.83,26.5 96.78,26.45 95.97,26.45 95.92,26.5 95.92,28.99 95.97,29.04 96.78,29.04
GND on TOP (solid shape): 109.74,37.8 109.74,32.39 109.64,32.29 104.25,32.29 104.18,32.36 104.18,37.83 104.23,37.88 109.66,37.88
GND on TOP (solid shape): 124.42,49.51 124.42,48.7 124.37,48.65 121.88,48.65 121.83,48.7 121.83,49.51 121.88,49.56 124.37,49.56
GND on TOP (solid shape): 125.57,45.76 125.57,44.84 125.49,44.75 120.97,44.75 120.48,45.24 120.48,45.73 120.59,45.84 125.49,45.84
GND on TOP (solid shape): 127.21,16.34 127.21,14.3 126.83,13.92 121.88,13.92 121.63,14.18 121.63,15.96 123.28,17.61 125.94,17.61
GND on TOP (solid shape): 135.95,15.5 135.95,14.38 135.72,14.15 135.04,14.15 135.01,14.18 135.01,15.73 135.06,15.78 135.67,15.78
GND on TOP (solid shape): 147.99,19.03 147.99,18.55 147.91,18.47 145.7,18.47 145.6,18.57 145.6,18.72 146.14,19.26 147.76,19.26
GND on TOP (solid shape): 151.09,30.69 151.09,28.17 149.92,27 146.77,27 146.57,27.21 146.57,30.1 147.46,30.99 150.78,30.99
GND on TOP (solid shape): 156.27,24.9 156.27,24.11 156.04,23.88 153.88,23.88 153.71,24.06 153.71,24.67 154.09,25.05 156.12,25.05
GND on TOP (solid shape): 160.13,24.85 160.13,24.19 159.95,24.01 158.99,24.01 158.71,24.29 158.71,24.92 158.89,25.1 159.88,25.1
GND on TOP (solid shape): 166.16,33.9 166.16,32.94 165.77,32.54 165.44,32.54 165.36,32.62 165.36,33.84 165.49,33.96 166.1,33.96
GND on TOP (solid shape): 171.79,15.78 171.79,14.97 171.74,14.91 169.3,14.91 169.25,14.97 169.25,15.78 169.3,15.83 171.74,15.83
GND on TOP (solid shape): 172.17,11.38 172.17,9.96 171.97,9.76 169.07,9.76 169,9.83 169,11.41 169.12,11.54 172.02,11.54
GND on TOP (solid shape): 174.1,28.27 174.1,27.77 173.86,27.53 172.56,27.53 172.2,27.89 172.2,28.27 172.27,28.35 174.03,28.35
GND on TOP (solid shape): 175.32,33.51 175.32,32.85 175.3,32.82 174.03,32.82 174,32.85 174,33.66 174.03,33.68 175.14,33.68
GND on TOP (solid shape): 191.63,45.06 191.63,44.25 191.58,44.2 189.09,44.2 189.04,44.25 189.04,45.06 189.09,45.11 191.58,45.11
GND on TOP (solid shape): 192.59,26.52 192.59,25.71 192.54,25.66 190.05,25.66 190,25.71 190,26.52 190.05,26.57 192.54,26.57
GND on TOP (solid shape): 202.47,21.62 202.47,19.13 202.42,19.08 201.61,19.08 201.56,19.13 201.56,21.62 201.61,21.67 202.42,21.67
GND on TOP (solid shape): 204.2,50.78 204.2,50.14 204.05,49.99 203.16,49.99 203.11,50.04 203.11,50.86 203.18,50.93 204.05,50.93
GND on TOP (solid shape): 209.01,48.65 209.01,47.25 208.48,46.71 207.49,46.71 207.26,46.95 207.26,48.92 207.29,48.95 208.71,48.95
GND on TOP (solid shape): 99.53,66.3 99.53,64.88 99.45,64.8 97.14,64.8 96.99,64.95 96.99,66.27 97.09,66.37 99.45,66.37
GND on TOP (solid shape): 134.35,17.2 134.35,16.39 134.2,16.24 133.56,16.24 133.39,16.41 133.39,17.17 133.56,17.35 134.2,17.35
GND on TOP (solid shape): 153.55,44.33 153.55,43.82 153.48,43.74 152.08,43.74 151.93,43.9 151.93,44.38 151.95,44.4 153.48,44.4
GND on TOP (solid shape): 202.88,35.79 202.88,35.26 202.63,35.01 198.71,35.01 198.71,35.82 201.84,35.82 201.99,35.97 202.7,35.97
GND on TOP (solid shape): 206.77,42.88 206.77,41.53 206.19,40.96 204.54,40.96 204.3,41.2 204.3,42.32 204.94,42.96 206.69,42.96
GND on TOP (solid shape): 92.21,56.39 92.21,55.27 92.14,55.2 89.47,55.2 89.34,55.33 89.34,56.47 89.46,56.58 92.02,56.58
GND on TOP (solid shape): 114.63,42.74 114.63,41.5 114.39,41.25 111.37,41.25 111.24,41.38 111.24,42.07 111.34,42.17 112.37,42.17 113.01,42.81 114.57,42.81
GND on TOP (solid shape): 121.73,32.24 121.73,31.6 121.47,31.35 120.25,31.35 120.2,31.4 120.2,32.34 120.28,32.41 121.55,32.41
GND on TOP (solid shape): 126.94,40.3 126.94,38.82 126.82,38.69 126.48,38.69 126.48,38.7 125.45,38.7 125.2,38.95 125.2,40.3 125.29,40.39 126.86,40.39
GND on TOP (solid shape): 133.97,11.82 133.89,11.74 133.46,11.74 133.28,11.92 133.28,13.09 133.49,13.29 133.97,13.29
GND on TOP (solid shape): 168.35,34.05 168.35,33.32 168.13,33.1 167.01,33.1 166.84,33.28 166.84,33.84 166.96,33.96 167.62,33.96 167.8,34.14 168.26,34.14
GND on TOP (solid shape): 193.43,30.76 193.43,29.82 193.2,29.6 190.64,29.6 190.51,29.72 190.51,30.74 190.79,31.02 193.18,31.02
GND on TOP (solid shape): 197.19,21.11 197.19,20.12 197.11,20.05 191.07,20.05 190.97,20.15 190.97,21.16 191.22,21.42 194.95,21.42 195.18,21.65 196.66,21.65
GND on TOP (solid shape): 200.59,45.8 200.59,44.35 200.52,44.28 199.07,44.28 198.97,44.38 198.97,45.9 198.99,45.93 200.47,45.93
GND on TOP (solid shape): 111.93,45.52 111.93,44.1 111.85,44.02 111.57,44.02 111.38,44.22 110.74,44.22 110.17,44.78 110.17,46.09 111.36,46.09
GND on TOP (solid shape): 143.8,21.42 143.8,21.06 143.7,20.96 141.16,20.96 141.11,21.01 141.11,21.49 141.21,21.59 143.62,21.59
GND on TOP (solid shape): 170.6,36.45 170.6,35.26 170.52,35.18 169.73,35.18 169.53,35.39 169.53,35.59 169.81,35.87 169.81,36.68 169.91,36.78 170.27,36.78
GND on TOP (solid shape): 203.11,18.01 203.11,17.61 203.21,17.51 204.18,17.51 204.45,17.23 204.45,16.21 204.2,15.96 202.83,15.96 202.24,16.54 202.24,18.29 202.37,18.42 202.7,18.42
GND on TOP (solid shape): 124.22,54.88 124.22,52.89 124.21,52.89 124.21,52.68 123.86,52.33 122.34,52.33 122.16,52.51 122.16,53.19 122.63,53.66 122.63,54.68 122.89,54.94 124.16,54.94
GND on TOP (solid shape): 19.36,39.48 19.36,38.59 19.06,38.28 18.81,38.28 18.63,38.46 18.63,38.74 18.4,38.97 17.76,38.97 17.42,39.31 17.42,39.84 17.46,39.88 18.96,39.88
GND on TOP (solid shape): 99.73,50.83 99.83,50.73 100.9,50.73 101.03,50.6 101.03,49.79 100.97,49.74 98.38,49.74 98.33,49.79 98.33,50.63 98.41,50.7 99.43,50.7 99.58,50.86 99.58,51.62 99.73,51.62
GND on TOP (solid shape): 161.5,34.95 161.5,31.07 161.35,30.92 158.51,30.92 158.46,30.97 158.46,32.63 157.55,33.54 157.55,34.79 157.85,35.08 161.38,35.08
GND on TOP (solid shape): 179.77,61.54 178.76,61.54 178.76,61.34 179.77,61.34 179.77,61.02 178.8,61.02 178.72,60.94 178.72,60.56 178.62,60.46 176.59,60.46 176.49,60.56 176.49,61.75 176.58,61.84 179.77,61.84
GND on TOP (solid shape): 126.93,31.27 126.93,31.07 126.91,31.04 126.1,31.04 125.97,30.92 125.97,29.95 125.84,29.82 125.64,29.82 125.49,29.98 125.49,31.02 125.77,31.3 126.91,31.3
GND on TOP (solid shape): 181.95,38 181.95,36.78 181.72,36.56 181.47,36.56 181.26,36.35 181.26,34.98 181.21,34.93 180.27,34.93 180.22,34.98 180.22,37.9 180.48,38.16 181.8,38.16
GND on TOP (solid shape): 198.08,22.81 198.28,22.81 198.43,22.66 198.43,18.19 198.36,18.11 198,18.11 197.83,18.29 197.83,21.34 196.99,22.18 196.99,23.09 197.14,23.25 197.65,23.25
GND on TOP (solid shape): 204.43,24.95 204.43,23.93 204.25,23.75 202.73,23.75 202.32,23.35 202.32,22.38 202.19,22.25 201.61,22.25 201.48,22.38 201.48,22.94 201.69,23.14 201.69,24.19 202.57,25.07 204.3,25.07
GND on TOP (solid shape): 41.62,57.48 41.62,46.94 40.73,46.05 40.73,45.04 40.7,45.01 38.49,45.01 38.44,45.06 38.44,46.18 38.57,46.31 39.33,46.31 39.79,46.77 39.79,52.79 40.57,53.57 40.57,57.54 40.65,57.61 41.49,57.61
GND on TOP (solid shape): 174.08,16.72 174.08,15.7 173.82,15.45 172.93,15.45 172.81,15.57 172.81,15.96 172.86,16.01 173.39,16.01 173.52,16.13 173.52,16.72 173.62,16.82 173.97,16.82
GND on TOP (solid shape): 223.89,31.01 223.89,29.79 224.49,29.19 224.49,27.71 223.99,27.71 223.99,26.27 223.9,26.18 223.56,26.18 223.49,26.25 223.49,28.21 223.99,28.21 223.99,28.98 223.58,29.39 223.58,30.42 223.39,30.42 223.39,31 223.48,31.09 223.81,31.09
GND on TOP (solid shape): 50.78,62.59 52.38,62.59 53.17,61.8 53.17,61.04 53.55,60.66 63.28,60.66 63.31,60.63 63.31,59.72 63.1,59.52 49.87,59.52 49.74,59.39 42.96,59.39 42.78,59.57 42.78,61.02 44.71,62.95 50.43,62.95
GND on TOP (solid shape): 89.23,37.14 89.57,36.98 89.91,37.14 91.4,37.14 91.4,32.16 84.56,32.16 84.56,37.09 84.61,37.14
GND on TOP (solid shape): 130.12,40.83 130.12,39.39 130.06,39.33 130.06,38.67 130.12,38.61 130.12,38.44 130.03,38.34 130.03,37.78 129.94,37.69 128.38,37.69 128.33,37.74 128.33,38.46 128.4,38.54 129.25,38.54 129.37,38.66 129.37,40.87 129.43,40.93 130.03,40.93
GND on TOP (solid shape): 162.11,18.72 162.11,18.6 162.01,18.5 157.64,18.5 157.62,18.52 156.98,18.52 156.96,18.5 155.66,18.5 155.64,18.52 154.95,18.52 154.92,18.5 149.54,18.5 149.49,18.55 149.49,18.65 149.51,18.67 150.76,18.67 150.86,18.78 152.69,18.78 153.04,19.13 161.71,19.13
GND on TOP (solid shape): 137.2,58.07 137.2,57.36 137.42,57.13 138.16,57.13 138.29,57 138.29,56.72 138.21,56.65 137.5,56.65 137.17,56.32 136.87,56.32 136.81,56.37 136.81,56.7 136.66,56.85 136.41,56.85 136.31,56.95 136.31,57.61 136.36,57.66 136.69,57.66 136.87,57.84 136.87,58.04 136.94,58.12 137.14,58.12
GND on TOP (solid shape): 211.89,40.8 211.89,38.64 215.15,38.64 215.15,39.14 222.79,39.14 222.79,34.39 223.79,34.39 223.89,34.29 223.89,32.95 223.74,32.79 223.5,32.79 223.39,32.91 223.39,33.89 222.29,33.89 222.29,38.64 215.65,38.64 215.65,38.14 209.78,38.14 209.1,38.82 209.1,40.7 209.43,41.03 211.67,41.03
GND on TOP (solid shape): 112.99,33.08 112.99,32.57 113.6,31.96 113.6,31.73 113.94,31.39 114.48,31.39 114.62,31.25 114.62,30.32 114.42,30.12 113.06,30.12 112.79,30.39 112.79,32.25 112.21,32.82 111.9,32.82 111.8,32.92 111.8,33.43 111.9,33.53 112.53,33.53
GND on TOP (solid shape): 141.26,33.76 141.26,33.53 141.4,33.39 141.65,33.39 141.66,33.39 141.82,33.35 141.98,33.39 141.99,33.39 142.64,33.39 142.68,33.35 142.68,31.63 142.61,31.55 141.89,31.55 141.82,31.48 138.29,31.48 136.87,32.9 136.87,33.35 137.5,33.99 138.76,33.99 138.88,34.11 140.91,34.11
GND on TOP (solid shape): 211.79,13.41 215.23,13.93 214.71,10.49 214.71,9.71 218.83,9.71 219.8,9.32 220.77,9.71 222.84,9.71 222.92,9.63 222.92,9.28 222.86,9.21 214.21,9.21 214.21,10.82 214.87,13.57 212.12,12.91 210.9,12.91 210.19,12.61 209.89,11.9 209.89,8.4 209.16,6.64 207.4,5.91 129.62,5.91 129.41,5.96 129.24,6.09 127.04,7.2 124.75,6.3 124.52,6.3 124.37,6.46 124.37,6.63 127.05,7.71 129.63,6.41 207.4,6.41 208.8,7 209.39,8.4 209.39,11.9 209.83,12.97 210.9,13.41
GND on TOP (solid shape): outline of 199 points within 0.51,0.51 224.49,70.49
GND on BOTTOM (solid shape): 62.85,66.27 61.45,66.27 61.45,67.46 62.85,67.46
GND on BOTTOM (solid shape): 9.48,57.23 7.71,57.23 7.63,57.31 7.63,58.48 7.71,58.55 9.48,58.55
GND on BOTTOM (solid shape): 175.09,50.86 172.83,50.86 172.53,51.16 172.53,56.7 172.7,56.88 175.09,56.88
GND on BOTTOM (solid shape): 25.59,43.01 25.03,42.45 21.37,42.45 21.07,42.75 21.07,44.61 25.59,44.61
GND on BOTTOM (solid shape): 175.55,66.83 175.55,65.74 175.4,65.59 173.64,65.59 173.64,66.93 175.45,66.93
GND on BOTTOM (solid shape): 106.56,60.94 104.48,60.94 104.48,64.06 106.56,64.06
GND on BOTTOM (solid shape): 111.95,45.58 111.95,43.04 111.42,42.5 108.64,42.5 108.45,42.7 108.45,46.1 111.43,46.1
GND on BOTTOM (solid shape): 120.03,6.3 120.03,6 119.94,5.91 117.4,5.91 117.31,6 117.31,6.31 117.41,6.41 119.92,6.41
GND on BOTTOM (solid shape): 167.78,29.5 167.78,28 167.68,27.89 167.08,27.89 166.9,28.07 166.9,29.48 167.04,29.62 167.67,29.62
GND on BOTTOM (solid shape): 39.18,29.06 39.18,26.24 38.93,25.99 36.79,25.99 36.66,26.12 36.66,29.21 36.79,29.34 38.9,29.34
GND on BOTTOM (solid shape): 170.67,22.31 170.67,21.59 170.52,21.44 169.96,21.44 169.76,21.65 169.76,22.51 169.83,22.59 170.39,22.59
GND on BOTTOM (solid shape): 55.2,66.88 55.2,65.99 55.08,65.87 52.92,65.87 52.79,65.99 52.79,66.88 52.92,67.01 55.08,67.01
GND on BOTTOM (solid shape): 89.75,36.81 89.75,32.34 89.62,32.21 86.45,32.21 86.32,32.34 86.32,36.91 86.4,36.99 89.57,36.99
GND on BOTTOM (solid shape): 146.56,19.36 146.56,18.75 146.33,18.53 145.46,18.53 145.27,18.72 145.27,19.45 145.4,19.58 146.34,19.58
GND on BOTTOM (solid shape): 170.27,43.74 170.27,42.68 170.19,42.6 166.23,42.6 166.23,43.08 168.28,43.08 168.28,43.41 166.23,43.41 166.23,43.9 170.11,43.9
GND on BOTTOM (solid shape): 184.63,11.55 184.63,9.1 184.61,9.08 183.02,9.08 182.99,9.11 182.99,11.55 183.03,11.59 184.59,11.59
GND on BOTTOM (solid shape): 189.3,10.01 189.3,7.08 189.16,6.95 187.84,6.95 187.69,7.09 187.69,9.96 187.79,10.06 189.24,10.06
GND on BOTTOM (solid shape): 178.67,61.68 178.67,60.58 178.55,60.46 176.74,60.46 176.51,60.69 176.51,61.7 176.64,61.83 178.52,61.83
GND on BOTTOM (solid shape): 25.54,50.93 25.78,50.93 26.01,50.7 26.01,49.38 25.84,49.22 25.6,49.22 21.08,49.22 21.07,49.23 21.07,50.91 21.09,50.93 25.54,50.93
GND on BOTTOM (solid shape): 132.09,66.07 132.09,64.83 131.35,64.09 128.48,64.09 127.77,64.8 127.77,67.16 128.13,67.52 130.64,67.52
GND on BOTTOM (solid shape): 154.94,28.17 156.78,28.17 156.96,28 156.96,27.13 156.69,26.87 156.08,26.87 155.89,26.67 152.54,26.67 152.21,27 152.21,28.27 152.48,28.55 154.57,28.55
GND on BOTTOM (solid shape): 171.02,8.31 173.37,8.31 173.4,8.28 173.4,6.87 173.17,6.64 170.2,6.64 170,6.84 170,8.31 170.11,8.41 170.91,8.41
GND on BOTTOM (solid shape): 28.18,67.01 28.18,64.75 28.15,64.72 27.65,64.72 26.15,63.23 25.97,63.23 25.56,63.63 25.56,64.77 25.89,65.1 25.89,66.96 26.1,67.16 28.03,67.16
GND on BOTTOM (solid shape): 94.88,67.26 94.88,65.65 93.82,65.65 93.81,65.66 87.79,65.66 87.67,65.79 87.67,67.34 87.72,67.39 94.75,67.39
GND on BOTTOM (solid shape): 125.33,8.36 125.33,8.16 124.06,6.89 124.06,6.13 123.96,6.02 120.53,6.02 120.3,6.25 120.3,8.41 120.43,8.54 125.16,8.54
GND on BOTTOM (solid shape): 147.33,28.41 147.33,28.31 147.47,28.17 151.34,28.17 151.39,28.12 151.39,26.8 151.27,26.67 147.82,26.67 147.82,26.67 146.68,26.67 146.6,26.74 146.6,28.25 146.83,28.48 147.25,28.48
GND on BOTTOM (solid shape): 164.47,33.23 164.47,32.61 164.55,32.53 166.27,32.53 166.63,32.16 166.63,28.94 166.52,28.82 164.2,28.82 163.66,29.37 163.66,33.27 163.76,33.38 164.32,33.38
GND on BOTTOM (solid shape): 172.96,39.2 174.97,39.2 175.07,39.09 175.07,37.91 175.04,37.88 173.8,37.88 173.74,37.82 173.73,37.82 173.73,37.31 173.69,37.27 171.5,37.27 171.13,37.64 170.38,37.64 170.09,37.93 170.09,40.47 171.69,40.47
GND on BOTTOM (solid shape): 214.84,37.8 214.84,36.78 214.72,36.66 214.03,36.66 213.6,36.22 213.6,35.54 213.45,35.39 211.29,35.39 211.03,35.64 211.03,37.67 211.29,37.93 214.72,37.93
GND on BOTTOM (solid shape): 182.36,63.43 183.07,63.43 183.09,63.4 183.09,62.95 183.07,62.92 182.36,62.92 182.36,61.42 180.38,61.42 180.38,63.45 182.36,63.45
GND on BOTTOM (solid shape): 9.36,10.54 11.39,10.54 11.44,10.49 11.44,9.81 11.4,9.76 9.49,9.76 9.47,9.74 9.47,9.32 9.49,9.29 11.4,9.29 11.44,9.25 11.44,8.08 11.19,7.83 7.33,7.83 7.17,7.98 7.17,10.39 7.35,10.57 7.35,10.6 9.3,10.6
GND on BOTTOM (solid shape): 161.6,34.45 161.6,33.76 162.29,33.07 162.29,31.77 162.23,31.7 160.3,31.7 160.09,31.92 160.09,32.48 159.73,32.85 158.07,32.85 157.85,33.08 157.85,34.57 157.97,34.7 161.35,34.7
GND on BOTTOM (solid shape): 105.75,26.14 105.75,23.22 105.57,23.04 102.09,23.04 101.69,23.45 101.69,24.77 101.84,24.92 102.47,24.92 102.68,25.13 102.68,25.96 102.91,26.19 105.45,26.19 105.45,26.22 105.47,26.24 105.65,26.24
GND on BOTTOM (solid shape): 122.44,30.87 122.44,28.7 122.4,28.66 118.98,28.66 118.93,28.71 118.93,29.47 118.53,29.87 117.25,29.87 117.25,29.88 117.25,30.17 118.06,30.17 118.06,30.49 117.25,30.49 117.25,30.81 118.06,30.81 118.06,31.15 117.25,31.15 117.25,31.44 117.28,31.48 121.83,31.48
GND on BOTTOM (solid shape): 107.4,14.18 107.4,13.29 106.77,12.65 106.77,10.9 106.51,10.65 106.51,7.93 106.41,7.83 105.95,7.83 105.88,7.9 105.88,10.62 105.72,10.77 105.14,10.77 105.03,10.66 105.03,7.92 104.94,7.83 104.35,7.83 104.1,8.08 104.1,13.92 104.86,14.69 106.89,14.69
GND on BOTTOM (solid shape): 141.34,33.53 141.34,32.67 141.29,32.62 141.29,31.99 141.29,31.99 141.29,31.78 141.26,31.75 140.96,31.75 140.96,32.59 140.64,32.59 140.64,31.75 140.3,31.75 140.3,32.59 139.98,32.59 139.98,31.75 138.72,31.75 138.34,31.37 138.34,30.21 138.26,30.13 135.95,30.13 135.9,30.18 135.9,33.1 136.87,34.07 140.8,34.07
GND on BOTTOM (solid shape): 211.89,41.06 211.89,38.64 215.15,38.64 215.15,39.14 222.79,39.14 222.79,34.39 223.79,34.39 223.89,34.29 223.89,32.82 223.82,32.75 223.45,32.75 223.39,32.81 223.39,33.89 222.29,33.89 222.29,38.64 215.65,38.64 215.65,38.14 209.66,38.14 208.77,39.02 208.77,40.77 209.18,41.18 211.77,41.18
GND on BOTTOM (solid shape): 125.31,18.7 126.15,18.7 126.15,18.35 125.35,18.35 125.35,18.03 126.15,18.03 126.15,17.7 125.37,17.7 125.37,17.38 126.15,17.38 126.15,14.23 125.87,13.95 124.75,13.95 124.5,14.2 124.5,15.7 123.45,16.74 123.45,16.82 123.05,17.23 122.31,17.23 122.23,17.3 122.23,18.62 122.44,18.83 125.18,18.83
GND on BOTTOM (solid shape): 206.97,59.39 206.97,58.88 207.22,58.63 207.22,57.79 207.05,57.61 206.31,57.61 206.13,57.79 206.13,58.25 206.14,58.26 206.18,58.44 206.14,58.62 206.13,58.63 206.13,59.14 206.14,59.15 206.17,59.23 206.18,59.31 206.33,59.47 206.89,59.47
GND on BOTTOM (solid shape): 134.33,24.25 134.33,23.92 133.03,22.43 132.72,20.48 131.73,20.48 131.6,20.61 131.6,24.33 131.7,24.43 134.14,24.43
GND on BOTTOM (solid shape): 107.56,66.65 107.56,65.71 107.34,65.49 107.18,65.49 107.17,65.49 106.54,65.49 106.41,65.36 106.41,64.34 106.23,64.34 106.23,65.34 106.02,65.34 106.02,64.34 105.83,64.34 105.83,65.34 105.62,65.34 105.62,64.34 105.43,64.34 105.43,65.33 105.22,65.33 105.22,64.34 105.03,64.34 105.03,65.33 104.82,65.33 104.82,64.34 104.61,64.34 104.61,65.35 104.49,65.46 104.25,65.46 104.02,65.69 104.02,66.63 104.2,66.81 107.41,66.81
GND on BOTTOM (solid shape): outline of 327 points within 63.23,45.88 65.64,54.89
GND on BOTTOM (solid shape): outline of 89 points within 124.37,5.91 224.49,31.09
GND on BOTTOM (solid shape): outline of 247 points within 0.51,0.51 224.49,70.49
GND on BOTTOM (solid shape): outline of 1969 points within 41.54,41.97 55.51,47.48
GND on GND (solid shape): outline of 53995 points within 0.51,0.51 224.49,70.49
GND on IN1 (solid shape): 62.86,64.62 59.22,64.62 59.22,67.47 62.86,67.47
GND on IN1 (solid shape): 42,53.22 42,52.3 41.95,52.25 41.36,52.25 41.13,52.48 41.13,53.34 41.22,53.43 41.78,53.43
GND on IN1 (solid shape): 111.95,45.58 111.95,43.04 111.42,42.5 108.64,42.5 108.45,42.7 108.45,46.1 111.43,46.1
GND on IN1 (solid shape): 89.23,37.14 89.57,36.98 89.91,37.14 91.4,37.14 91.4,32.16 84.56,32.16 84.56,37.14
GND on IN1 (solid shape): 211.89,40.75 211.89,38.64 215.15,38.64 215.15,39.14 222.79,39.14 222.79,34.39 223.79,34.39 223.89,34.29 223.89,32.9 223.76,32.76 223.47,32.76 223.39,32.85 223.39,33.89 222.29,33.89 222.29,38.64 215.65,38.64 215.65,38.14 209.43,38.14 208.92,38.64 208.92,40.29 209.56,40.92 211.72,40.92
GND on IN1 (solid shape): 48.47,60.66 48.56,60.61 48.56,60.52 48.86,60.05 49.17,60.52 49.17,60.61 49.26,60.66 49.98,60.66 50.37,60.27 50.37,59.89 50.32,59.84 43.88,59.84 43.48,59.44 42.78,59.44 42.58,59.64 42.58,60.36 42.64,60.42 46,60.42 46.24,60.66
GND on IN1 (solid shape): outline of 87 points within 42,42.14 54.67,47.48
GND on IN1 (solid shape): outline of 85 points within 124.37,5.91 224.49,31.09
GND on IN1 (solid shape): outline of 177 points within 0.51,0.51 224.49,70.49
GND on IN2 (solid shape): 62.86,64.62 59.22,64.62 59.22,67.47 62.86,67.47
GND on IN2 (solid shape): 91.4,32.4 84.56,32.4 84.56,36.96 91.4,36.96
GND on IN2 (solid shape): 111.95,45.42 111.95,43.04 111.42,42.5 108.64,42.5 108.45,42.7 108.45,46.1 111.28,46.1
GND on IN2 (solid shape): 211.89,40.55 211.89,38.64 215.15,38.64 215.15,39.14 222.79,39.14 222.79,34.39 223.79,34.39 223.89,34.29 223.89,32.9 223.79,32.8 223.45,32.8 223.39,32.86 223.39,33.89 222.29,33.89 222.29,38.64 215.65,38.64 215.65,38.14 210.93,38.14 209.1,39.96 209.1,40.82 209.38,41.1 211.34,41.1
GND on IN2 (solid shape): outline of 85 points within 124.37,5.91 224.49,31.09
GND on IN2 (solid shape): outline of 179 points within 0.51,0.51 224.49,70.49
GND on SGND1 (solid shape): outline of 2236 points within 0.51,0.51 224.49,70.49
GND on SVCC (solid shape): outline of 680 points within 203.29,7.43 222.84,68.67
GND on SVCC (solid shape): outline of 1059 points within 2.03,7.13 112.1,54.82
GND on IN3 (solid shape): 91.4,32.16 86.75,32.16 84.56,34.35 84.56,36.25 91.4,36.25
GND on IN3 (solid shape): 111.95,45.13 111.95,43.04 111.42,42.5 108.64,42.5 108.45,42.7 108.45,46.03 108.52,46.1 110.98,46.1
GND on IN3 (solid shape): 211.89,41.06 211.89,38.64 215.15,38.64 215.15,39.14 222.79,39.14 222.79,34.39 223.79,34.39 223.89,34.29 223.89,32.87 223.82,32.8 223.45,32.8 223.39,32.86 223.39,33.89 222.29,33.89 222.29,38.64 215.65,38.64 215.65,38.14 210.67,38.14 208.82,39.98 208.82,40.72 209.36,41.25 211.69,41.25
GND on IN3 (solid shape): outline of 98 points within 122.06,52.25 224.49,70.19
GND on IN3 (solid shape): outline of 85 points within 124.37,5.91 224.49,31.09
GND on IN3 (solid shape): outline of 82 points within 0.51,0.51 120.03,68.39
GND on IN4 (solid shape): 62.86,64.62 59.22,64.62 59.22,67.47 62.86,67.47
GND on IN4 (solid shape): 91.4,32.16 86.72,32.16 84.56,34.32 84.56,36.27 91.4,36.27
GND on IN4 (solid shape): 111.95,45.58 111.95,43.04 111.42,42.5 108.64,42.5 108.64,42.51 108.64,45.98 111.55,45.98
GND on IN4 (solid shape): 41.84,47.3 41.84,47.07 41.69,46.92 39.66,46.92 39.53,47.05 39.53,47.2 40.17,47.83 41.31,47.83
GND on IN4 (solid shape): 42.78,51.77 42.78,50.32 42.71,50.25 41.82,50.25 41.69,50.37 41.69,50.78 42.15,51.24 42.15,51.44 42.53,51.82 42.73,51.82
GND on IN4 (solid shape): 211.89,40.57 211.89,38.64 215.15,38.64 215.15,39.14 222.79,39.14 222.79,34.39 223.79,34.39 223.89,34.29 223.89,32.97 223.71,32.8 223.53,32.8 223.39,32.94 223.39,33.89 222.29,33.89 222.29,38.64 215.65,38.64 215.65,38.14 210.72,38.14 208.87,39.98 208.87,40.62 209.38,41.13 211.34,41.13
GND on IN4 (solid shape): outline of 227 points within 41.49,45.7 64.25,48.21
GND on IN4 (solid shape): outline of 85 points within 124.37,5.91 224.49,31.09
GND on IN4 (solid shape): outline of 186 points within 0.51,0.51 224.49,70.49
GND on GND2 (solid shape): outline of 69970 points within 0.51,0.51 224.49,70.49
1P35V_BOOT on TOP (solid shape): 119.54,34.82 119.58,34.78 119.58,34.39 119.85,34.12 119.85,32.85 119.72,32.72 119.09,32.72 118.96,32.85 118.96,33.74 119.34,34.12 119.34,34.24 119.39,34.3 119.39,34.62 119.34,34.68 119.34,35.84 119.54,35.84
1P35V_LGATE on TOP (solid shape): 118.35,36.07 117.36,36.07 117.33,36.05 117.33,34.75 117.23,34.65 116.65,34.65 116.6,34.7 116.6,34.93 116.98,35.31 116.98,36.05 117.21,36.28 118.35,36.28
1P35V_PHASE on TOP (solid shape): 118.75,34.75 118.58,34.57 118.58,32.85 118.45,32.72 117.84,32.72 117.74,32.82 117.74,34.27 118.2,34.73 118.4,34.73 118.53,34.85 118.53,35.87 118.75,35.87
1P35V_PHASE on BOTTOM (solid shape): 116.62,27.06 114.77,27.06 114.31,26.6 114.31,25.48 114.03,25.2 111.9,25.2 111.74,25.35 111.74,30.33 112.13,30.71 113.23,30.71 113.31,30.67 113.32,30.57 113.74,30.06 113.96,30.68 113.95,30.72 113.97,30.75 114.23,31.02 114.23,31.5 116.62,31.5
1P35V_VLDOIN on BOTTOM (solid shape): 106.13,32.24 106.13,32.07 105.51,31.45 104.92,31.45 104.83,31.54 104.83,31.89 105.53,32.59 105.78,32.59
8230_BOOT1 on TOP (solid shape): 155.53,40.03 155.53,39.37 155.51,39.35 154.8,39.35 154.72,39.43 153.73,39.43 153.65,39.35 152.46,39.35 152.46,39.55 153.63,39.55 153.68,39.6 153.81,39.6 154.26,40.06 155.51,40.06
8230_BOOT2 on TOP (solid shape): 148.98,39.97 148.98,39.78 149.21,39.55 150.25,39.55 150.25,39.35 149.23,39.35 149.14,39.44 149.14,39.44 148.04,39.44 147.93,39.34 147.19,39.34 147.18,39.35 147.18,40.03 147.2,40.06 148.89,40.06
8230_LGAT2 on TOP (solid shape): 150.28,38.16 149.27,38.16 149.26,38.14 148.92,37.8 148.92,37.15 148.83,37.06 148.25,37.06 148.19,37.11 148.19,37.5 149.03,38.35 150.28,38.35
8230_LGAT2 on BOTTOM (solid shape): 142.22,34.04 142.22,32.95 141.95,32.67 141.95,31.83 141.61,31.83 141.61,33.61 141.44,33.79 141.44,34.12 141.59,34.27 142,34.27
8230_LGATE1 on TOP (solid shape): 154,38.02 154.41,38.02 154.44,38 155.03,37.41 155.03,37.06 154.85,36.89 154.47,36.89 153.81,37.55 153.81,37.72 153.49,38.04 153.49,38.14 153.47,38.16 152.46,38.16 152.46,38.34 153.67,38.34
8230_LGATE1 on BOTTOM (solid shape): 163.1,33.48 163.1,32.8 162.95,32.64 162.95,31.83 162.93,31.81 162.65,31.81 162.62,31.83 162.62,32.67 162.47,32.82 162.47,33.46 162.6,33.58 163,33.58
8230_PHASE1 on TOP (solid shape): 153.73,38.68 154.04,38.68 154.04,38.68 154.16,38.66 154.28,38.68 154.29,38.68 154.62,38.68 154.64,38.71 154.67,38.71 154.73,38.76 155.48,38.76 155.53,38.71 155.53,38.05 155.51,38.03 154.72,38.03 154.6,38.15 154.06,38.15 153.68,38.54 152.49,38.54 152.49,38.76 153.65,38.76
8230_PHASE1 on BOTTOM (solid shape): 163.28,31.2 163.28,29.04 162.6,28.35 162.6,28.15 162.19,27.74 162.19,26.75 161.91,26.47 158.07,26.47 157.22,27.33 157.22,28.36 157.52,28.66 157.52,29.56 157.54,29.58 159.27,29.58 160.61,30.93 160.61,31.21 160.73,31.32 163.15,31.32
8230_PHASE2 on TOP (solid shape): 148.02,38.65 148.98,38.65 149.07,38.74 150.25,38.74 150.25,38.74 150.25,38.56 150.25,38.56 149.05,38.56 148.55,38.05 147.96,38.05 147.93,38.03 147.13,38.03 147.13,38.74 147.94,38.74
8230_PHASE2 on BOTTOM (solid shape): 142.43,30.99 142.43,29.39 143.24,28.58 145.02,28.58 145.14,28.7 145.14,29.56 145.2,29.62 146.97,29.62 147.08,29.52 147.08,28.81 146.94,28.67 146.8,28.67 146.08,27.95 145.79,27.95 145.63,27.79 145.63,26.44 145.4,26.22 142.07,26.22 140.4,27.89 140.04,27.89 138.88,29.05 138.88,30.78 139.33,31.22 142.2,31.22
8230_UGATE1 on TOP (solid shape): 154.65,39.15 154.65,38.89 154.56,38.81 153.79,38.81 153.65,38.94 152.46,38.94 152.46,39.15 153.65,39.15 153.81,39.3 154.49,39.3
8230_UGATE2 on TOP (solid shape): 149.08,39.15 150.28,39.15 150.28,38.94 149.08,38.94 148.95,38.81 148.1,38.81 148.04,38.87 148.04,39.19 148.13,39.28 148.95,39.28
51622_V5A on BOTTOM (solid shape): 28.71,57.92 28.71,57.36 28.41,57.05 28.03,57.05 27.82,56.85 27.73,56.85 27.51,56.87 27.31,56.75 26.96,56.75 26.6,57.1 25.89,57.1 25.87,57.13 25.87,57.23 25.89,57.26 26.63,57.26 26.71,57.33 27.49,57.33 28.15,57.99 28.64,57.99
51622_VREF on BOTTOM (solid shape): 28.18,60.38 28.43,60.38 28.71,60.1 28.71,58.5 28.56,58.35 28.31,58.35 27.44,57.48 25.92,57.48 25.84,57.56 25.84,57.64 25.87,57.66 26.76,57.66 27.49,58.4 27.49,60.38 27.65,60.53 28.03,60.53
+DC_IN on TOP (solid shape): 10.75,25.73 10.75,23.52 10.4,23.17 7.66,23.17 7.33,23.5 7.33,24.08 7.07,24.34 7.07,25.61 7.5,26.04 10.45,26.04
+DC_IN on BOTTOM (solid shape): 45.76,31.45 46.97,31.45 47.1,31.32 47.1,29.06 46.92,28.88 44.64,28.88 42.48,31.04 27.92,31.04 23,26.12 11.34,26.12 9.28,24.06 9.28,23.52 8.85,23.09 6.61,23.09 6.46,23.25 6.46,24.95 10.22,28.71 21.93,28.71 26.86,33.63 43.57,33.63
+DC_IN_S on BOTTOM (solid shape): 120.58,23.07 120.58,20.15 120.37,19.93 114.64,19.93 114.13,20.44 114.13,23.47 114.39,23.73 119.92,23.73
+DC_IN_S on BOTTOM (solid shape): 80.88,30.66 95.77,30.66 96.17,30.26 96.17,28.5 95.74,28.07 79.79,28.07 78.98,28.88 53.81,28.88 53.71,28.99 53.71,31.4 53.76,31.45 80.1,31.45
+DC_IN_S on IN3 (solid shape): outline of 177 points within 94.22,20.4 117.89,30.54
+DC_IN_SS on BOTTOM (solid shape): 123,22.76 123,21.39 123.43,20.96 123.43,20.38 123.3,20.25 122.9,20.25 122.82,20.32 122.82,20.71 122.62,20.91 122.21,20.91 122.03,21.09 121.22,21.09 121.17,21.14 121.17,22.71 121.24,22.79 122.97,22.79
+DCIN_JACK on TOP (solid shape): 8.6,21.67 8.6,18.75 8.47,18.62 7.58,18.62 7.45,18.75 7.45,21.67 7.58,21.8 8.47,21.8
+DCIN_JACK on BOTTOM (solid shape): 10.65,22.15 10.65,15.14 11.39,14.41 11.39,13.53 11.37,13.51 9.49,13.51 9.44,13.47 9.44,13.08 9.49,13.04 11.37,13.04 11.39,13.01 11.39,12.26 7.58,12.26 7.55,12.32 7.48,12.4 7.48,22.08 7.83,22.43 10.37,22.43
+DVDIO on TOP (solid shape): 105.17,40.47 105.39,40.47 105.83,40.04 105.83,38.21 105.8,38.18 105.57,38.18 105.55,38.21 105.55,39.93 105.27,40.21 104,40.21 103.97,40.24 103.97,40.9 104.02,40.95 104.69,40.95
+DVDIO on BOTTOM (solid shape): 107.07,40.42 107.07,38.89 106.74,38.56 105.5,38.56 105.37,38.69 105.37,40.09 105.75,40.47 107.02,40.47
+DVDIO on IN3 (solid shape): 105.98,39.37 105.98,38.84 105.85,38.71 105.75,38.71 103.82,40.64 103.82,41.08 103.88,41.14 104.22,41.14
+LCDVCC on TOP (solid shape): 201.56,52.33 201.56,50.53 201.46,50.42 200.89,50.42 200.33,50.98 200.33,52.37 200.42,52.46 201.43,52.46
+LCDVCC on TOP (solid shape): 184.11,54.34 184.11,53.12 184.34,52.89 185.84,52.89 186.04,53.09 186.93,53.09 187.02,53 187.02,52.01 186.9,51.9 182.66,51.9 182.54,52.02 182.54,53.6 182.97,54.03 182.97,54.54 183.12,54.69 183.75,54.69
+LCDVCC on BOTTOM (solid shape): 200.48,52.82 200.48,51.75 200.56,51.67 200.72,51.67 200.73,51.68 200.73,52.82 200.74,52.84 200.95,52.84 200.98,52.81 200.98,51.66 201.13,51.52 201.36,51.52 201.51,51.36 201.51,50.59 201.33,50.42 200.44,50.42 200.37,50.49 200.37,51.14 200.17,51.34 200.17,51.59 200.23,51.66 200.23,52.8 200.27,52.84 200.46,52.84
+LCDVCC on IN3 (solid shape): 185.13,54.16 185.13,53.32 184.86,53.05 182.89,53.05 182.73,53.21 182.73,53.74 182.97,53.98 182.97,54.61 183.14,54.79 184.49,54.79
+LCDVCC on IN3 (solid shape): 201.64,51.46 201.64,49.28 201.3,48.95 198.05,48.95 198.04,48.95 197.9,48.98 197.77,48.95 197.76,48.95 197.31,48.95 197.3,48.95 197.16,48.98 197.03,48.95 197.02,48.95 196.57,48.95 196.56,48.95 196.43,48.98 196.29,48.95 196.28,48.95 195.51,48.95 195.26,49.2 195.26,50.63 195.51,50.88 196.81,50.88 197.16,50.53 198.74,50.53 199.1,50.88 199.55,50.88 199.59,50.84 199.96,50.56 200.29,50.89 200.31,50.91 200.31,51.57 200.47,51.72 201.38,51.72
+LED_BL on TOP (solid shape): 203.92,52.38 203.92,51.24 203.79,51.11 203.11,51.11 202.96,50.96 202.96,50.5 202.82,50.36 201.84,50.36 201.71,50.49 201.71,52.43 201.81,52.53 203.77,52.53
+LED_BL on BOTTOM (solid shape): 171.79,58.53 171.79,51.13 171.51,50.86 168.79,50.86 168.69,50.96 168.69,58.65 168.92,58.88 171.43,58.88
+LED_BL on BOTTOM (solid shape): 201.98,52.83 201.98,51.68 202,51.66 202.22,51.66 202.23,51.68 202.23,52.82 202.25,52.84 202.47,52.84 202.52,52.79 202.52,51.74 202.88,51.39 202.88,50.5 202.75,50.37 201.89,50.37 201.73,50.53 201.73,52.8 201.77,52.84 201.97,52.84
+LED_BL on SVCC (solid shape): 181.38,54.82 181.34,54 182.02,53.53 182.1,53.45 183.88,53.45 184.44,54 184.44,54.77 184.49,54.82 184.62,54.82 184.9,54.64 185.17,54.82 202.08,54.82 202.29,54.61 202.35,53.99 202.81,53.58 202.86,53.44 202.95,53.32 203.92,52.35 203.92,51.47 202.57,50.12 202.23,50.12 200.9,51.45 200.85,51.51 200.78,51.56 200.72,51.62 200.56,51.73 200.37,51.77 173.24,51.77 172.85,52.05 172.47,51.77 169.08,51.77 168.62,52.23 168.62,54.35 169.08,54.82
+LED_PWRSRC on BOTTOM (solid shape): 172.78,64.65 170.69,62.55 170.53,62.55 169.89,61.9 169.17,61.9 168.92,62.16 168.92,64.16 168.41,64.67 164.35,64.67 163.84,65.18 162.54,65.18 162.54,66.2 164.02,66.2 164.75,66.93 172.78,66.93
+PWR_SRC on TOP (solid shape): 126.58,13.16 126.58,12.27 126.2,11.89 121.24,11.89 120.99,12.15 120.99,13.29 121.37,13.67 126.07,13.67
+PWR_SRC on TOP (solid shape): 158.2,32.41 158.2,31.02 158.12,30.94 157.59,30.94 157.44,31.09 156.04,31.09 155.9,31.24 155.9,33 156.2,33.31 157.31,33.31
+PWR_SRC on TOP (solid shape): 150.45,33.71 152.74,33.71 152.94,33.51 152.94,30.87 152.68,30.6 151.58,30.6 151.01,31.17 146.72,31.17 146.57,31.32 143.34,31.32 143.01,31.65 143.01,33.2 143.19,33.38 145.58,33.38 146.59,34.4 149.77,34.4
+PWR_SRC on BOTTOM (solid shape): 25,67.34 25,64.6 24.75,64.34 22.95,64.34 22.69,64.09 22.69,63.58 22.57,63.45 20.53,63.45 20.41,63.58 20.41,65.49 21.17,66.25 21.7,66.25 21.83,66.37 21.83,67.24 22.11,67.52 24.83,67.52
+PWR_SRC on BOTTOM (solid shape): 157.74,32.64 159.5,32.64 159.55,32.59 159.55,30.15 159.47,30.08 156.04,30.08 155.95,29.99 155.95,29.37 155.95,29.37 155.95,28.95 155.86,28.86 151.42,28.86 151.32,28.76 147.66,28.76 147.51,28.91 147.51,29.85 147.25,30.1 144.56,30.1 144.46,30.21 144.46,33.27 144.71,33.52 154.94,33.52 155,33.58 156.8,33.58
+PWR_SRC on BOTTOM (solid shape): 122.35,27.83 122.36,27.82 123.63,27.82 124.06,27.39 126.2,27.39 126.45,27.13 126.45,26.37 125.18,25.1 124.8,25.1 124.42,24.72 121.07,24.72 120.79,25 118.73,25 118.65,24.92 118.65,24.19 118.48,24.01 115,24.01 114.94,24.06 114.94,26.32 115.02,26.4 117.95,26.4 118.13,26.57 118.13,27.55 118.41,27.83 119.02,27.83
+PWR_SRC on BOTTOM (solid shape): 163.43,67.29 163.43,66.45 163.33,66.35 162.32,66.35 162.1,66.13 162.1,65.46 161.97,65.33 158.12,65.33 158.02,65.43 158.02,65.97 158.18,66.12 158.46,66.12 158.79,66.45 158.79,67.31 159.01,67.54 163.18,67.54
+PWR_SRC on BOTTOM (solid shape): 16.72,61.17 16.72,59.39 16.62,59.29 15.45,59.29 15.22,59.06 15.22,56.57 15.18,56.52 15.18,56.5 15.13,56.32 15.18,56.14 15.18,55.16 15.17,55.15 11.18,55.15 11.14,55.1 11.14,53.45 11.11,53.42 8.04,53.42 8.01,53.45 8.01,56.79 8.1,56.88 9.69,56.88 9.84,57.03 9.84,58.53 9.97,58.65 11.51,58.65 11.63,58.78 11.63,60.9 11.77,61.04 15.63,61.04 15.86,61.27 16.62,61.27
+PWR_SRC on BOTTOM (solid shape): 118.25,67.42 118.25,65.87 118.53,65.59 124.01,65.59 125.31,66.88 127.34,66.88 127.47,66.76 127.47,64.47 127.34,64.34 119.87,64.34 119.49,64.8 119.12,64.34 116.76,64.34 116.65,64.23 115.78,64.23 114.91,64.32 114.05,64.19 110.14,64.19 109.18,63.23 106.89,63.23 106.89,63.39 107.87,63.39 107.88,63.4 107.88,63.59 106.89,63.59 106.89,63.79 107.87,63.79 107.87,63.99 107.86,63.99 106.89,63.99 106.89,64.72 107.76,65.59 107.76,66.12 107.93,66.3 108.26,66.3 108.7,65.87 115.12,65.87 115.22,65.97 115.22,67.34 115.5,67.62 118.04,67.62
+PWR_SRC on BOTTOM (solid shape): 121.88,13.77 121.88,13.09 121.88,13.06 123.25,13.06 123.25,13.67 123.33,13.75 126.22,13.75 126.86,13.11 130.06,13.11 130.26,12.91 134.76,12.91 135.24,12.43 135.24,8.74 134.53,8.03 126.04,8.03 125.33,8.74 124.29,8.74 124.09,8.95 120.79,8.95 120.46,9.28 120.46,10.84 120.63,11.02 120.63,11.78 120.64,11.79 120.64,12.39 130.51,12.39 130.52,12.33 130.53,12.28 130.56,12.22 130.59,12.18 130.62,12.13 130.66,12.1 130.71,12.07 130.76,12.04 130.81,12.03 130.87,12.02 130.92,12.02 130.98,12.03 131.03,12.04 131.08,12.07 131.13,12.1 131.17,12.13 131.21,12.18 131.24,12.22 131.26,12.28 131.27,12.33 131.28,12.39 131.28,12.44 131.27,12.5 131.25,12.55 131.22,12.6 131.19,12.64 131.15,12.68 131.11,12.72 131.06,12.75 131.01,12.77 130.95,12.78 130.9,12.78 130.84,12.78 130.79,12.77 130.73,12.75 130.69,12.72 130.64,12.68 130.6,12.64 130.57,12.6 130.54,12.55 130.53,12.5 130.52,12.44 130.51,12.39 120.64,12.39 120.64,13.65 120.91,13.92 121.73,13.92
+PWR_SRC on SVCC (solid shape): outline of 2800 points within 8.48,10.88 163.79,68.97
+SMDDR_VREF_CA on SVCC (solid shape): outline of 155 points within 15.28,12.88 96,18.93
+SMDDR_VREF_DQB on BOTTOM (solid shape): 77.86,27.72 77.86,27.21 77.61,26.95 74.48,26.95 74.41,27.03 74.41,27.79 74.61,28 77.58,28
+USB0_SIDE_PWR on TOP (solid shape): 206.72,48.87 206.72,47.32 206.08,46.69 205.14,46.69 204.48,46.03 202.98,46.03 202.65,45.7 200.97,45.7 200.92,45.75 200.92,47.22 201.43,47.73 201.43,48.57 201.53,48.67 203.74,48.67 204.18,49.1 206.49,49.1
+USB0_SIDE_PWR on TOP (solid shape): outline of 102 points within 206.72,38.05 211.87,43.9
+USB0_SIDE_PWR on BOTTOM (solid shape): 210.14,37.24 210.14,35.44 210.83,34.75 213.19,34.75 213.53,34.41 213.53,32.46 213.24,32.17 213.24,30.21 212.66,29.62 210.68,29.62 207.83,32.47 207.83,33.66 206.59,34.9 206.59,39.07 206.84,39.32 208.06,39.32
+USB0_SIDE_PWR on IN1 (solid shape): outline of 92 points within 206.84,37.93 212.18,43.9
+USB0_SIDE_PWR on IN2 (solid shape): outline of 372 points within 202.55,38.05 209,49.2
+V_VDDQ_VR on TOP (solid shape): 116.27,22.2 116.27,21.44 115.99,21.16 115.99,20.25 115.88,20.15 115.4,20.15 115.25,20.3 115.25,22.08 115.43,22.25 116.21,22.25
+V_VDDQ_VR on TOP (solid shape): 104.63,15.37 104.63,10.42 103.72,9.5 99.22,9.5 99.07,9.35 97.11,9.35 96.99,9.48 96.99,10.52 97.72,11.26 102.8,11.26 103.06,11.51 103.06,15.24 103.31,15.5 104.51,15.5
+V_VDDQ_VR on TOP (solid shape): outline of 277 points within 49.34,35.07 63.78,47.35
+V_VDDQ_VR on BOTTOM (solid shape): 63.69,47.17 63.69,46.64 63.54,46.49 63.21,46.49 62.95,46.23 62.67,46.23 62.06,46.84 59.93,46.84 59.78,46.69 59.78,46.08 59.62,45.93 59.45,45.93 59.27,46.11 59.27,46.61 59.06,46.82 58.63,46.82 58.48,46.66 58.48,46.05 58.35,45.93 58.18,45.93 57.95,46.16 57.95,46.64 57.72,46.87 56.09,46.87 55.86,46.64 55.86,46.05 55.71,45.9 55.56,45.9 55.36,46.11 55.36,47.25 55.51,47.4 63.46,47.4
+V_VDDQ_VR on BOTTOM (solid shape): outline of 26137 points within 12.28,6.58 108.8,39.3
+VCHGR on TOP (solid shape): 116.06,15.5 116.06,14.13 116.01,14.08 116.01,11.61 115.94,11.53 115.53,11.53 115.22,11.85 115.21,11.88 115.19,12.02 115.11,12.13 114.73,12.52 114.73,15.41 114.97,15.65 115.91,15.65
+VCHGR on BOTTOM (solid shape): 121.51,19.47 121.51,17.28 121.26,17.02 118.86,17.02 118.56,16.73 118.56,15.38 117.64,14.46 117.64,8.13 117.42,7.92 116.41,7.92 116.37,7.95 116.37,10.65 116.35,10.67 115.54,10.67 115.53,10.65 115.53,7.94 115.51,7.92 114.88,7.92 114.87,7.93 114.87,10.77 114.82,10.82 114.82,14.58 114.83,14.6 114.04,15.38 114.04,19.19 114.46,19.61 121.37,19.61
+VCHGR_IN on TOP (solid shape): 131.12,22.45 131.12,19.96 130.9,19.74 129.37,19.74 129.12,19.99 129.12,22.41 129.3,22.59 130.99,22.59
+VCHGR_IN on BOTTOM (solid shape): 131.23,24.35 131.23,20.5 131.45,20.27 132.37,20.27 132.47,20.17 132.47,17.73 132.29,17.56 129.94,17.56 129.78,17.72 129.78,19.18 129.17,19.79 128.38,19.79 128.08,20.1 128.08,21.44 128.09,21.45 128.76,21.45 128.76,22.8 128.08,22.8 128.08,22.81 128.08,23.88 128.77,24.57 131,24.57
AUD_SPK_R+ on TOP (solid shape): 17.23,34.65 17.23,34.47 16.8,34.04 16.65,34.04 15.91,34.78 15.91,35.34 16.04,35.46 16.42,35.46
AUD_SPK_R+ on TOP (solid shape): 89.8,24.44 90.18,24.44 90.26,24.36 90.26,23.8 90.13,23.68 88.81,23.68 88.66,23.83 88.66,24.34 88.76,24.44 89.04,24.44
AUD_SPK_R+ on BOTTOM (solid shape): 217.08,34.73 217.08,34.02 216.93,33.86 216.7,33.86 216.24,34.32 215.33,34.32 215.29,34.36 215.29,35.07 215.4,35.18 216.62,35.18
AUD_SPK_R+ on BOTTOM (solid shape): 16.06,37.61 16.06,35.92 16.47,35.51 16.47,35.13 16.27,34.93 15.83,34.93 15.73,35.04 15.73,35.84 15.75,35.86 15.75,37.61 15.78,37.64 16.03,37.64
AUD_SPK_R+ on IN1 (solid shape): 90.99,24.82 90.99,23.93 90.9,23.84 89.33,23.84 89.24,23.93 89.24,24.82 89.47,25.05 90.76,25.05
AUD_SPK_R+ on IN1 (solid shape): 217.76,33.66 217.76,33.25 217.59,33.08 216.75,33.08 215.96,33.86 215.96,34.8 216.06,34.9 216.52,34.9
AUD_SPK_R+_C on BOTTOM (solid shape): 216.14,33.56 216.14,31.9 216.13,31.88 216.13,28.78 215.33,28.78 215.33,33.66 215.35,33.68 216.01,33.68
AUD_SPK_R- on TOP (solid shape): 15.66,35.31 15.66,34.61 16.53,33.73 16.53,33.57 16.13,33.16 15.92,33.16 14.96,34.13 14.96,35.4 15.02,35.46 15.5,35.46
AUD_SPK_R- on TOP (solid shape): 90.26,23.3 90.26,22.84 90.13,22.71 88.75,22.71 88.72,22.74 88.72,23.36 88.78,23.42 90.13,23.42
AUD_SPK_R- on BOTTOM (solid shape): 215.2,36.07 215.2,35.79 214.75,35.35 214.75,34.35 214.73,34.32 214.03,34.32 213.97,34.38 213.97,35.73 214.46,36.22 215.05,36.22
AUD_SPK_R- on BOTTOM (solid shape): 15.55,37.59 15.55,35.99 15.62,35.91 15.62,35.1 15.45,34.93 14.97,34.93 14.82,35.08 14.82,35.56 15.24,35.99 15.24,37.59 15.27,37.61 15.52,37.61
AUD_SPK_R- on IN1 (solid shape): 219.14,35.46 219.14,34.83 218.83,34.52 218.35,34.52 216.98,35.89 215.86,35.89 215.15,35.18 214.21,35.18 214.03,35.36 214.03,35.84 215.15,36.96 217.64,36.96
AUD_SPK_R- on IN1 (solid shape): 90.14,23.3 90.3,23.26 90.46,23.25 90.54,23.25 90.79,22.99 90.79,21.72 90.64,21.57 89.9,21.57 89.29,22.18 89.29,23.19 89.39,23.3
AUD_SPK_R-_C on BOTTOM (solid shape): 214.87,33.59 214.87,33.07 214.87,33.07 214.87,28.78 214.08,28.78 214.08,31.87 214.04,31.9 214.04,33.65 214.06,33.66 214.79,33.66
CHARGER_AGND on TOP (solid shape): 125.18,29.42 125.18,27.77 124.93,27.51 123.53,27.51 123.28,27.77 123.28,28.4 123.66,28.78 123.66,29.42 123.78,29.54 125.05,29.54
CHARGER_AGND on TOP (solid shape): 134.92,37.22 134.92,36.25 134.84,36.18 133.86,36.18 133.08,36.96 130.57,36.96 130.3,36.69 130.3,36.06 130.17,35.93 127.87,35.93 127.7,36.1 127.7,37.22 127.94,37.46 131.21,37.46 131.46,37.7 134.44,37.7
CHARGER_AGND on BOTTOM (solid shape): 129.27,32.69 129.27,31.1 128.95,30.77 127.58,30.77 127.07,31.29 127.07,32.01 127.06,32.01 127.06,32.13 126.94,32.26 126.93,32.26 126.9,32.29 126.23,32.29 126.17,32.34 126.17,32.95 126.3,33.08 128.89,33.08
CHARGER_AGND on IN4 (solid shape): outline of 125 points within 122.41,28.41 135.02,37.23
IINP on TOP (solid shape): 129.47,44.36 129.47,43.93 129.48,43.87 130.15,43.2 130.15,41.78 129.42,41.06 129.37,41.06 129.24,40.93 129.24,39.7 129.13,39.59 128.17,39.59 127.92,39.35 127.92,38.76 127.85,38.69 127.31,38.69 127.21,38.79 127.21,40.44 127.34,40.57 127.8,40.57 128.03,40.8 128.03,41.28 128.1,41.36 128.69,41.36 129.3,41.97 129.3,43.33 129.3,43.34 129.08,43.56 129.08,43.56 128.74,43.89 128.74,44.44 128.83,44.52 129.31,44.52
OZ9955H_SW on TOP (solid shape): 180.26,59.84 180.47,59.84 180.47,60.86 180.77,60.86 180.77,58.49 180.58,58.3 176.59,58.3 176.49,58.4 176.49,59.97 176.59,60.08 179.94,60.08 179.94,60.86 180.26,60.86
OZ9955H_SW on BOTTOM (solid shape): 176.39,60.1 179.41,60.1 179.63,59.89 179.63,57.94 179.35,57.66 173.36,57.66 173.24,57.79 173.24,59.57 175.04,61.37 175.12,61.37
SWR_GND on TOP (solid shape): 103.03,40.64 103.03,40.03 103.79,39.27 104.29,39.27 104.35,39.22 104.35,38.21 104.04,38.21 104.02,38.22 103.83,38.41 103.46,38.41 102.24,39.63 102.24,40.67 102.3,40.72 102.96,40.72
SWR_GND on BOTTOM (solid shape): 103.62,39.45 104.07,39.45 104.18,39.35 104.18,37.09 103.87,36.78 102.47,36.78 102.35,36.66 102.2,36.66 102.19,36.7 102.14,36.84 102.05,36.96 102.01,37.04 102.05,37.12 101.81,37.8 101.58,37.12 101.62,37.04 101.58,36.96 101.48,36.84 101.43,36.7 101.43,36.66 100.95,36.66 100.54,36.25 100.54,35.87 100.31,35.64 97.34,35.64 97.11,35.87 97.11,37.14 96.71,37.55 95.95,37.55 95.84,37.65 95.84,39.35 96.07,39.58 97.09,39.58 97.88,40.37 102.7,40.37
SWR_GND on GND (solid shape): 103.61,39.45 104.07,39.45 104.18,39.35 104.18,37.09 103.87,36.78 102.47,36.78 102.34,36.66 102.24,36.66 102.19,36.7 102.19,36.72 102.13,36.86 102.03,36.97 101.99,37.05 102.03,37.13 101.81,37.78 101.6,37.13 101.64,37.05 101.6,36.97 101.49,36.86 101.44,36.72 101.43,36.7 101.38,36.66 100.95,36.66 100.54,36.25 100.54,35.87 100.31,35.64 97.35,35.64 97.11,35.87 97.11,37.14 96.71,37.55 95.95,37.55 95.84,37.65 95.84,39.35 96.08,39.58 97.09,39.58 97.88,40.37 102.7,40.37
SWR_GND on IN1 (solid shape): 102.75,40.31 102.75,39.46 101.04,37.74 101.04,36.75 100.54,36.25 100.54,35.87 100.31,35.64 97.34,35.64 97.11,35.87 97.11,37.14 96.71,37.55 95.95,37.55 95.84,37.65 95.84,39.35 96.07,39.58 97.09,39.58 97.88,40.37 102.7,40.37
