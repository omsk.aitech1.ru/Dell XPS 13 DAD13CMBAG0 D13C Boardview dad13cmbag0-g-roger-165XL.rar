# Allegro board dad13cmbag0-g-roger-165XL.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
I2C0_SCL: length 19.7
  IN3 w0.089: v2(89.34,55.5) 88.33,55.5 86.91,56.92 85.86,56.92 85.52,57.27 78.98,57.27 78.79,57.08 77.84,57.08 v2(76.71,58.2)
  BOTTOM w0.127: v2(89.34,55.5) 89.34,55.73 89.71,56.1 Q24.3 91.21,56.1 91.63,56.52 93.18,56.52 93.41,56.29 93.41,56.04 93.66,55.78 RP27.2
I2C0_SCL_DSP: length 73
  TOP w0.127: v4(99.19,30.97) 99.53,30.97 99.67,31.11 99.74,31.11 99.88,30.96 99.88,30.68 101.66,28.91 105.1,28.91 105.41,29.22 105.41,29.58 v7(105.8,29.98) 105.34,30.43 105.34,30.66 105.14,30.87 105.14,30.94 105.19,31 U10.27
  IN1 w0.089: v4(99.19,30.97) 99.04,31.13 98.63,31.13 98.35,31.41 98.35,32.96 98.74,33.35 99.86,33.35 100.23,33.72 104.7,33.72 105.55,32.87 109,32.87 109.53,33.41 110.83,33.41 111.27,33.85 111.27,36.75 114.5,39.97 114.5,43.4 114.87,43.77 115.14,43.77 v9(115.3,43.94)
  IN2 w0.089: v5(90.03,53.84) 90.03,53.83 90.01,53.82 90.01,53.64 90.75,52.9 99.03,52.9 103.36,48.57 110.45,48.57 111.16,47.86 111.72,47.86 113.93,45.65 113.93,44.2 114.39,43.74 115.11,43.74 v9(115.3,43.94)
  IN3 w0.089: v5(90.03,53.84) 89.94,53.93 89.94,54.02 91.42,55.5 v2(91.42,55.5)
  BOTTOM w0.127: v2(91.42,55.5) 91.42,55.6 91.92,56.1 Q24.4
I2C0_SDA: length 20.1
  IN3 w0.089: v2(91.53,54.81) 91.53,54.8 91.78,55.06 91.78,55.71 91.53,55.96 88.14,55.96 86.98,57.11 85.95,57.11 85.68,57.38 85.67,57.38 85.6,57.46 78.9,57.46 78.8,57.36 78.14,57.36 v2(77.26,58.24)
  BOTTOM w0.127: v2(91.53,54.81) 91.53,54.8 Q24.6 92.96,54.8 93.41,54.36 v6(93.76,54.36) 94.12,54.72 RP27.4 ; U16.F2 v2(77.26,58.24)
I2C0_SDA_DSP: length 69.4
  TOP w0.127: v4(99.19,31.62) 99.56,31.62 99.69,31.49 99.9,31.49 100.26,31.12 100.26,30.84 101.81,29.29 104.94,29.29 105.03,29.38 105.03,29.48 v7(104.53,29.98) 104.96,30.41 104.96,30.5 104.76,30.71 104.76,30.94 104.69,31 U10.26
  IN1 w0.089: v9(115.3,43.26) 115.14,43.43 115.01,43.43 114.84,43.26 114.84,39.83 111.62,36.61 111.62,33.71 110.97,33.06 109.67,33.06 109.14,32.53 105.41,32.53 104.56,33.38 100.37,33.38 100,33.01 98.88,33.01 98.69,32.82 98.69,31.55 98.77,31.47 99.04,31.47 v4(99.19,31.62)
  IN2 w0.089: v9(115.3,43.26) 115.16,43.4 114.24,43.4 113.59,44.06 113.59,45.51 111.58,47.52 111.02,47.52 110.31,48.23 103.22,48.23 98.89,52.56 90.61,52.56 89.67,53.5 89.67,53.69 v5(89.52,53.84)
  IN3 w0.089: v5(89.52,53.84) 89.6,53.92 89.6,54.17 v2(90.23,54.81)
I2C1_SCL: length 23.1
  IN3 w0.089: v2(93.53,53.76) 93.53,53.35 v2(92.56,52.38) 92.29,52.1 91.53,52.1 91.37,52.25 91.37,53.9 92.29,54.82 92.29,55.99 91.68,56.6 88.04,56.6 87.14,57.49 86.16,57.49 85.66,57.99 78.3,57.99 v2(78.01,58.28)
  BOTTOM w0.127: RP29.2 93.61,53.49 93.53,53.57 v2(93.53,53.76) ; Q25.3 v2(92.56,52.38)
I2C1_SDA: length 26.7
  IN3 w0.089: v2(93.49,52.38) 93.01,51.9 91.45,51.9 91.15,52.2 91.15,53.23 v2(90.49,53.89) 91.11,54.51 91.68,54.51 92.06,54.89 92.06,55.86 91.7,56.21 88.15,56.21 87.06,57.3 86.04,57.3 85.56,57.79 78.12,57.79 77.38,58.53 76.51,58.53 76.06,58.08 76.06,57.67 v2(76.06,57.66)
  BOTTOM w0.127: RP29.4 93.64,52.84 93.49,52.69 v2(93.49,52.38) 93.76,52.11 v6(93.76,51.95) ; U16.G4 76.06,57.66 v2(76.06,57.66) ; Q25.6 v2(90.49,53.89)
I2S_BCLK_OUT: length 90.5
  TOP w0.127: U11.10 185.28,35.11 v6(185.44,35.28) ; v9(106.41,30.69) 106.19,30.9 U10.29
  IN2 w0.089: v9(106.41,30.69) 106.51,30.69 107.25,31.42 108.39,31.42 110.21,33.24 112.65,33.24 113.7,34.29 117,34.29 117.61,33.68 119.94,33.68 121.03,34.78 129.91,34.78 130.69,35.56 132.34,35.56 132.52,35.39 134.07,35.39 134.73,36.05 143.37,36.05 143.6,35.82 149.77,35.82 150.38,36.43 152.23,36.43 152.64,36.02 153.71,36.02 153.86,36.17 155.08,36.17 156.04,37.14 156.04,37.57 157.16,38.69 161,38.69 161.45,39.15 173.97,39.15 176.72,36.4 178.44,36.4 178.66,36.19 178.66,34.97 178.78,34.85 180.71,34.85 181.14,35.29 181.14,36.12 181.42,36.4 183.27,36.4 184.4,35.28 v6(185.44,35.28)
I2S_SDI_IN: length 92.7
  TOP w0.127: v6(185.28,33.48) 184.79,33.48 184.36,33.91 U11.7
  IN1 w0.089: v4(110.54,34.36) 110.54,34.04 110.6,33.98 v9(110.6,33.68)
  IN2 w0.089: v6(185.28,33.48) 185.56,33.48 185.63,33.48 186.17,34.02 186.17,35.74 184.62,37.29 180.5,37.29 180.38,37.16 180.38,35.29 180.3,35.21 180.02,35.21 179.94,35.29 179.94,36.81 179.87,36.89 179.55,36.89 179.49,36.82 179.49,35.29 179.41,35.21 179.13,35.21 179.04,35.3 179.04,36.52 178.8,36.76 176.9,36.76 174.05,39.6 160.56,39.6 160,39.04 157.01,39.04 155.69,37.72 155.69,37.29 154.95,36.56 153.71,36.56 153.58,36.43 152.77,36.43 152.41,36.78 150.23,36.78 149.6,36.16 143.94,36.16 143.71,36.39 134.54,36.39 133.89,35.74 132.67,35.74 132.5,35.92 130.54,35.92 129.78,35.16 120.93,35.16 119.81,34.04 117.84,34.04 117.23,34.65 113.52,34.65 112.56,33.68 v9(110.6,33.68)
I2S_SDO_OUT: length 92
  TOP w0.127: v6(184.82,34.14) 184.65,34.31 U11.8 ; U10.31 107.19,31.05 107.43,30.81 107.91,30.81 v9(108.04,30.69) v7(108.04,29.85)
  IN2 w0.089: v9(108.04,30.69) 108.72,30.69 110.43,32.39 112.82,32.39 114.01,33.58 116.7,33.58 117.46,32.82 121.9,32.82 122.51,33.43 124.57,33.43 125.18,34.04 130.18,34.04 131,34.85 132.04,34.85 132.24,34.65 134.38,34.65 135.04,35.31 142.94,35.31 143.11,35.13 150.17,35.13 150.76,35.72 151.9,35.72 152.31,35.31 154.01,35.31 154.16,35.46 155.38,35.46 156.75,36.83 156.75,37.27 157.39,37.9 161.25,37.9 161.71,38.36 173.42,38.36 174.97,36.81 174.97,35.01 176.84,33.13 178.11,33.13 178.2,33.22 178.2,33.44 178.29,33.53 178.47,33.53 178.56,33.44 178.56,33.22 178.65,33.13 178.83,33.13 178.91,33.22 178.91,33.44 179,33.53 179.18,33.53 179.27,33.44 179.27,33.22 179.36,33.13 182.28,33.13 182.37,33.22 182.37,34.1 182.43,34.17 183.04,34.17 183.13,34.08 183.13,33.19 183.3,33.03 184.16,33.03 184.29,33.15 184.29,34.06 184.38,34.14 v6(184.82,34.14)
I2S_SFRM_OUT: length 93.2
  TOP w0.127: U10.30 106.69,30.99 106.94,30.74 v9(106.94,30.69) ; v7(186.29,34.27) 186.01,34.27 v6(185.61,34.66) 185.56,34.71 U11.9
  IN2 w0.089: v6(185.61,34.66) 185.59,34.69 182.8,34.69 182.71,34.78 182.71,35.01 182.62,35.09 182.01,35.09 181.92,35.01 181.92,34.88 181.87,34.83 181.44,34.83 181.13,34.52 181.13,33.62 181.07,33.56 180.38,33.56 180.29,33.65 180.29,34.38 180.2,34.47 180.03,34.47 179.94,34.38 179.94,33.65 179.85,33.56 179.67,33.56 179.58,33.65 179.58,34.38 179.49,34.47 178.55,34.47 178.27,34.75 178.27,35.77 178.01,36.02 176.36,36.02 173.67,38.71 161.55,38.71 161.12,38.28 157.26,38.28 156.4,37.42 156.4,36.99 155.23,35.82 154.01,35.82 153.86,35.67 152.46,35.67 152.05,36.07 150.56,36.07 149.96,35.48 143.38,35.48 143.19,35.67 134.88,35.67 134.22,35.01 132.39,35.01 132.19,35.21 130.85,35.21 130.06,34.42 121.16,34.42 120.07,33.33 117.46,33.33 116.85,33.94 113.85,33.94 112.7,32.78 110.26,32.78 108.55,31.07 107.56,31.07 107.17,30.69 v9(106.94,30.69)
IFB1: length 26.2
  TOP w0.203: v6(185.63,67.02) PR5.2 PR4.2
  IN4 w0.203: v2(196.36,52.86) 196.35,52.86 187.67,52.86 187.35,53.18 187.35,56.18 186.78,56.75 186.78,65.88 v6(185.63,67.02)
  BOTTOM w0.127: J1.13 196.36,52.25 v2(196.36,52.86)
IFB2: length 28.7
  TOP w0.203: PR2.2 PR3.2 182.75,67.02 v6(182.89,67.16)
  IN4 w0.203: v6(182.89,67.16) 184.14,67.16 186.4,64.91 186.4,56.57 186.95,56.01 186.95,52.99 187.47,52.47 196.64,52.47 v2(196.86,52.25)
IFB3: length 34.9
  TOP w0.203: PR225.2 178.11,67.02 v6(177.96,67.16) 177.38,67.16 176.86,66.65 PR223.2
  IN4 w0.203: v6(177.96,67.16) 177.96,67.19 178.53,66.59 183.94,66.59 186.01,64.52 186.01,56.39 186.55,55.86 186.55,52.89 187.31,52.13 196.4,52.13 196.63,51.9 197,51.9 v2(197.36,52.25)
IFB4: length 37.5
  TOP w0.127: PR224.2 175.73,64.27 v6(175.42,64.57)
  TOP w0.203: v6(176.26,65.94) 176.61,65.6 PR221.2 176.61,64.87 176.35,64.61 PR224.2
  IN4 w0.203: v6(176.26,65.94) 176.49,66.17 183.86,66.17 185.63,64.39 185.63,56.27 186.17,55.73 186.17,52.76 187.17,51.76 196.19,51.76 196.35,51.59 197.2,51.59 v2(197.86,52.25)
IINP: length 39
  TOP w0.127: U4.F12 v4(140.51,57.53) ; PC55.1 127.26,38.91 127.26,37.98 127.47,37.77 127.47,36.01 PC68.1 127.98,35.21 v6(128.69,34.5) 128.75,34.43 PU12.7
  IN1 w0.089: v9(143.49,43.77) 143.47,43.79 143.47,47.25 144.05,47.83 144.05,51.95 144.61,52.51 144.61,55.97 144.64,55.99 144.64,57.1 144.43,57.31 142.38,57.31 142.16,57.53 v4(140.51,57.53)
  IN2 w0.089: v9(129.6,43.07) 138.15,43.07 138.54,42.68 142.4,42.68 v9(143.49,43.77)
IMVP7_PROCHOT#: length 180.8
  TOP w0.127: v9(139.06,37.58) 139.06,37.57 139.06,36.57 v7(138.67,36.17) 138.67,35.29 C156.1 138.22,35.14 137.8,34.73 136.99,34.73 PQ11.3
  IN1 w0.089: v5(29.65,56.6) 29.42,56.6 29.04,56.98 29.04,58.15 29.65,58.75 34.91,58.75 36.46,60.3 36.46,61.72 37.07,62.91 37.08,62.91 40.47,66.3 51.72,66.3 52.21,65.82 52.21,63.53 52.73,63.01 63.98,63.01 65.59,64.62 72.25,64.62 73.48,65.85 77.34,65.85 77.78,65.42 80.18,65.42 82.1,67.33 86.22,67.33 87.21,66.35 92.85,66.35 93.81,67.31 108.16,67.31 110.14,65.33 121.41,65.33 121.51,65.32 121.8,65.33 123.5,65.33 125.4,67.24 129.52,67.24 129.91,67.62 134.13,67.62 134.48,67.26 142.83,67.26 v4(144.1,65.99) 145.2,64.9 145.2,61.09 146.15,60.14 146.15,59.53 147.36,58.32 147.36,56 146.56,55.21 146.56,52.12 145.7,51.27 145.7,45.06 149.57,41.2 v9(149.57,40.97)
  IN2 w0.089: v9(149.57,40.97) 147.84,40.97 146.62,39.76 145.96,39.76 143.73,37.53 139.11,37.53 v9(139.06,37.58)
  IN4 w0.089: v2(29.28,56.6) v5(29.65,56.6)
  BOTTOM w0.127: R279.1 33.68,55.58 33.56,55.46 R283.2 R282.2 31.46,55.96 30.16,55.96 29.52,56.6 PR179.2 v2(29.28,56.6)
IMVP_PWRGD: length 17
  TOP w0.127: PD9.1 44.54,63.5 v2(43.6,62.56) ; PD9.1 44.8,64.73 PC218.1 PR226.2 ; PD9.1 43.27,64.47 v7(43.14,64.6)
  IN1 w0.089: v2(43.6,62.56) 43.6,61.88 v5(43.75,61.73)
  IN4 w0.089: v5(43.75,61.73) 43.6,61.88 v2(43.6,62.56)
  BOTTOM w0.127: U16.C59 42.11,60.61 42.82,61.31 42.82,61.79 v2(43.6,62.56) 44.97,62.56 45.91,63.5 45.91,65.71 46.07,65.88 R262.2
INT_AUX_SINKN: length 12.6
  TOP w0.14: C55.2 205.31,57.11 205.31,57.32 204.39,58.24 204.24,58.24 v7(203.74,57.74) 203.24,58.24 202.53,58.24 201.43,59.34 200.95,59.34 200.53,58.92 U3.5 200.53,55.21 200.61,55.13 R71.1 R81.2
INT_AUX_SINKP: length 13.1
  TOP w0.14: R12.2 R11.1 201.38,63.89 201.83,63.43 U3.2 201.83,61.06 201.28,60.51 201.28,59.72 201.39,59.61 201.54,59.61 202.64,58.51 203.24,58.51 v7(203.74,59.01) 204.24,58.51 204.5,58.51 205.58,57.43 205.58,57.11 C56.2
INT_DP_AUXN: length 148.9
  TOP w0.14: C55.1 205.24,55.65 205.24,54.8 205.95,54.08 206.31,54.08 v6(206.44,53.95)
  IN2 w0.127: v5(74.58,60.79) 74.63,60.75 74.63,60.59 74.94,60.28 75.73,60.28 80.3,55.71 81.06,54.94 86.24,54.94 87.32,56.02 98.91,56.02 104.21,50.72 112.41,50.72 113.75,49.38 116.11,49.38 119.59,45.9 122.67,45.9 123.41,45.17 132.09,45.17 132.27,45.34 138.75,45.34 139.4,44.7 141.35,44.7 143.66,47.01 149.86,47.01 150.47,47.62 160.09,47.62 160.31,47.83 168.91,47.83 169.34,47.4 174.99,47.4 175.94,48.35 189.48,48.35 193.55,52.42 194.41,52.42 197.61,55.62 204.15,55.62 205.76,54 206.38,54 v6(206.44,53.95)
  IN4 w0.127: v5(74.58,60.79) 74.58,60.85 74.37,61.07 v2(73.9,61.07)
INT_DP_AUXP: length 148.9
  TOP w0.14: C56.1 205.5,55.5 205.5,54.91 206.06,54.35 206.21,54.35 206.44,54.58 v6(206.44,54.64)
  IN2 w0.127: v6(206.44,54.64) 206.44,54.51 206.26,54.34 205.9,54.34 204.28,55.95 204.01,55.95 197.47,55.95 194.27,52.75 193.41,52.75 189.34,48.68 175.8,48.68 174.85,47.73 169.48,47.73 169.05,48.16 160.17,48.16 159.96,47.95 150.33,47.95 149.72,47.34 143.52,47.34 141.21,45.03 139.53,45.03 138.89,45.67 132.13,45.67 131.96,45.5 123.55,45.5 122.81,46.23 119.73,46.23 116.25,49.71 113.89,49.71 112.54,51.05 104.34,51.05 99.05,56.35 87.18,56.35 86.11,55.27 81.2,55.27 80.86,55.61 75.86,60.61 75.08,60.61 74.96,60.73 74.96,61.03 v5(75.02,61.09)
  IN4 w0.127: v2(74.26,61.71) 74.26,61.46 74.32,61.4 74.5,61.4 74.81,61.09 v5(75.02,61.09)
INT_DP_HPD: length 174.9
  TOP w0.127: R3.1 207.48,65.74 v9(206.23,64.5) 205.22,65.51 204.45,65.51 204.06,65.11 R14.1 203.67,66.07 v7(203.57,66.17)
  IN2 w0.089: v5(72.65,60.99) 72.6,61.05 72.12,61.05 71.76,60.69 71.76,60.18 71.54,59.96 71.54,59.52 72.48,58.58 75.55,58.58 80.76,53.37 80.76,52.51 81.34,51.92 81.34,50.88 83.09,49.13 88.78,49.13 89.27,48.65 93.28,48.65 94.85,47.07 96,47.07 96.28,47.35 98.72,47.35 101.03,45.04 105.06,45.04 106.33,43.77 106.33,42.09 107.92,40.5 117.14,40.5 117.68,41.04 124.08,41.04 124.8,40.31 128.66,40.31 129.09,40.75 131.84,40.75 132.14,41.05 137.5,41.05 138.11,40.44 140.8,40.44 141.28,40.92 143.44,40.92 146.09,43.57 152,43.57 152.13,43.69 154.57,43.69 155.03,44.15 165.92,44.15 166.91,43.16 171.07,43.16 172.51,44.6 178.63,44.6 180.11,46.08 184.12,46.08 184.39,45.81 190.6,45.81 192.22,47.44 192.73,47.44 197.7,52.4 206.08,52.4 207.74,54.06 207.74,62.99 v9(206.23,64.5)
  IN4 w0.089: v2(73.14,61.47) 73.03,61.47 72.65,61.09 v5(72.65,60.99)
  BOTTOM w0.127: U16.A8 73.24,61.47 v2(73.14,61.47)
INT_DP_HPD_R: length 10
  TOP w0.127: v7(206.36,67.8) 205.57,67.01 Q1.3 206.64,66.48 206.8,66.64 R3.2 R4.1 208.97,66.64 209.92,65.69 v6(210.58,65.69)
  BOTTOM w0.127: CN1.2 210.91,64.6 211.18,64.87 211.18,65.41 210.89,65.69 v6(210.58,65.69)
INT_DP_SCL: length 155.6
  TOP w0.14: v4(72.96,60.02) 73.16,60.22 RP3.1 ; v4(194.88,59.62) 195.09,59.4 195.24,59.4 v7(195.74,59.9) 196.24,59.4 196.97,59.4 196.97,59.4 198.17,59.4 198.4,59.64 U2.2
  IN1 w0.127: v4(72.96,60.02) 72.78,60.2 72.78,60.28 v5(73.01,60.51) ; v9(198.41,54.91) 198.15,54.65 197.99,54.65 195.89,56.75 195.89,58.81 195.29,59.42 195.08,59.42 v4(194.88,59.62)
  IN2 w0.127: v5(73.01,60.51) 73,60.5 73,59.84 73.08,59.76 75.53,59.76 79.94,55.35 80.85,54.44 86.56,54.44 87.64,55.51 98.65,55.51 103.95,50.22 111.25,50.22 111.89,49.58 112.26,49.58 112.28,49.56 112.28,49.56 115.09,46.75 117.94,46.75 119.32,45.37 122.44,45.37 123.23,44.58 138.8,44.58 139.18,44.19 141.59,44.19 143.88,46.47 150.23,46.47 150.87,47.11 159.52,47.11 160.74,45.89 166.52,45.89 167.13,45.28 171.06,45.28 171.73,45.95 177.94,45.95 179.66,47.68 189.54,47.68 193.75,51.9 194.6,51.9 197.49,54.78 198.28,54.78 v9(198.41,54.91)
  IN4 w0.127: v5(73.01,60.51) 72.82,60.32 72.82,60.18 v2(73.07,59.93)
INT_DP_SDA: length 155.6
  TOP w0.14: U2.5 197.1,58.61 196.58,59.14 196.24,59.14 v7(195.74,58.63) 195.24,59.14 195.09,59.14 v4(194.88,58.92) ; v4(72.28,60.02) 72.51,60.02 72.95,59.57 RP3.3
  IN1 w0.127: v5(72.22,60.51) 72.45,60.28 72.45,60.2 v4(72.28,60.02) ; v4(194.88,58.92) 195.04,59.08 195.15,59.08 195.56,58.67 195.56,56.61 197.85,54.32 198.32,54.32 v9(198.41,54.23)
  IN2 w0.127: v9(198.41,54.23) 198.19,54.45 197.62,54.45 194.74,51.57 193.89,51.57 189.67,47.35 179.8,47.35 178.07,45.62 171.87,45.62 171.19,44.95 166.99,44.95 166.38,45.56 160.6,45.56 159.38,46.78 151,46.78 150.37,46.14 144.02,46.14 141.73,43.86 139.05,43.86 138.66,44.25 123.09,44.25 122.3,45.04 119.18,45.04 117.8,46.42 114.95,46.42 112.15,49.23 112.14,49.23 112.12,49.25 111.75,49.25 111.11,49.89 103.81,49.89 98.51,55.18 87.77,55.18 86.7,54.11 80.71,54.11 78.79,56.03 75.39,59.43 72.94,59.43 72.67,59.7 72.67,60.36 72.52,60.51 v5(72.22,60.51)
  IN4 w0.127: v2(72.16,59.93) 72.48,60.24 72.48,60.38 72.34,60.51 v5(72.22,60.51)
INT_DP_TXN0: length 5.7
  TOP w0.14: C7.2 209.92,63.96 211.05,65.09 211.88,65.09 212.2,64.77 212.2,64.1 CN1.5
INT_DP_TXN0_C: length 182.8
  TOP w0.14: C7.1 207.45,63.56 206.64,63.56 206.24,63.16 205.24,63.16 v6(204.93,63.47)
  IN2 w0.127: v6(204.93,63.47) 204.65,63.19 199.97,63.19 193.29,56.51 192.22,56.51 188.66,52.95 177.16,52.95 175.99,54.12 171.67,54.12 170.49,55.3 166.22,55.3 164.91,53.99 147.93,53.99 146.95,53.01 146.95,51.97 145.95,50.97 141.98,50.97 140.07,49.06 134.8,49.06 134.58,49.29 128,49.29 125.57,51.71 123.29,51.71 122.79,52.21 118.95,52.21 117.72,53.45 114.93,53.45 113.17,55.2 106.2,55.2 101.7,59.7 95.28,59.7 92.83,62.15 86.81,62.15 85.6,60.94 82.27,60.94 76.85,66.35 72.26,66.35 71.06,65.14 64.94,65.14 63.52,63.72 52.31,63.72 51.73,64.29 49.03,64.29 v5(48.79,64.53)
  IN4 w0.127: v5(48.79,64.53) 48.65,64.39 48.04,64.39 47.34,63.7 47.34,61.56 47.06,61.28 47.06,60.49 47.13,60.42 v2(47.13,60.41)
INT_DP_TXN1: length 5.1
  TOP w0.14: C16.2 209,61.29 209.31,61.29 v7(209.81,60.79) 210.32,61.29 210.64,61.29 211.09,61.74 212.46,61.74 CN1.11
INT_DP_TXN1_C: length 183.6
  TOP w0.14: v6(204.95,60.34) 204.95,60.44 205.2,60.7 205.99,60.7 206.73,61.44 207.66,61.44 207.85,61.25 C16.1
  IN2 w0.127: v5(44.37,62.59) 44.61,62.35 46.33,62.35 46.44,62.25 49.52,62.25 49.76,62.01 64.26,62.01 65.73,63.47 71.98,63.47 72.46,63.95 75.41,63.95 77.43,61.93 77.43,61.44 80.84,58.02 99.93,58.02 105.17,52.79 113.19,52.79 114.6,51.39 117.39,51.39 118.36,50.42 122.05,50.42 125.29,47.17 130.96,47.17 131.15,47.36 141.1,47.36 142.79,49.05 148.21,49.05 150.01,50.86 153.14,50.86 154.05,51.77 157.79,51.77 158.24,52.21 166.58,52.21 167.14,51.66 172.17,51.66 172.87,50.96 175.08,50.96 175.37,51.25 189.47,51.25 193.06,54.83 193.98,54.83 198.91,59.76 205.09,59.76 205.5,60.16 205.5,60.42 205.38,60.53 205.15,60.53 v6(204.95,60.34)
  IN4 w0.127: v5(44.37,62.59) 44.37,62.55 44.49,62.44 44.85,62.44 45.18,62.1 45.18,61.21 45.53,60.87 45.53,60.64 v2(45.75,60.41)
INT_DP_TXN2: length 5.4
  TOP w0.14: C20.2 208.92,59.9 209.03,59.8 209.03,59.26 209.14,59.15 209.55,59.15 209.64,59.06 209.64,58.89 209.71,58.82 210.02,58.82 210.21,59.01 210.4,59.01 210.59,58.82 210.84,58.82 211.03,59.01 211.24,59.01 211.43,58.82 211.62,58.82 211.94,59.14 211.94,59.45 CN1.17
INT_DP_TXN2_C: length 183.7
  TOP w0.14: v6(205.8,59.32) 206.01,59.11 206.69,59.11 207.1,59.52 207.47,59.52 C20.1
  IN2 w0.127: v5(48.86,60.38) 49.04,60.56 57,60.56 58.11,59.45 65.4,59.45 66.07,58.78 68.03,58.78 71.55,62.3 72.47,62.3 72.95,62.78 74.93,62.78 76.26,61.45 76.26,60.95 80.36,56.86 99.34,56.86 104.57,51.62 112.7,51.62 114.1,50.22 116.9,50.22 117.88,49.24 121.35,49.24 122.49,48.1 122.49,47.45 123.93,46 131.58,46 131.76,46.19 139.1,46.19 139.72,45.56 140.99,45.56 143.32,47.88 149.41,47.88 150,48.47 158.73,48.47 160.58,50.31 171.8,50.31 172.4,49.71 175.52,49.71 175.88,50.07 189.95,50.07 193.55,53.66 194.47,53.66 197.3,56.49 198.59,56.49 198.92,56.82 198.92,57.91 199.48,58.48 204.05,58.48 205.09,57.43 205.09,56.1 205.41,55.78 206.39,55.78 206.72,56.1 206.72,58.68 206.33,59.06 206.06,59.06 v6(205.8,59.32)
  IN4 w0.127: v5(48.86,60.38) 48.71,60.53 48.37,60.53 v2(48.26,60.41)
INT_DP_TXN3: length 3.5
  BOTTOM w0.14: C244.2 206.9,61.76 208.28,61.76 208.44,61.6 CN1.12
INT_DP_TXN3_C: length 185.6
  IN2 w0.127: v5(44.34,63.72) 44.34,64.06 44.41,64.14 45.53,64.14 46.8,62.87 49.62,62.87 49.96,62.53 64.01,62.53 65.46,63.97 71.77,63.97 72.25,64.46 72.26,64.46 72.77,64.97 76.57,64.97 79.84,61.7 79.84,59.92 80.63,59.14 86.83,59.14 87.43,58.53 100.94,58.53 106.16,53.31 113.4,53.31 114.8,51.91 117.6,51.91 118.56,50.94 122.4,50.94 122.81,50.53 124.81,50.53 126.13,49.21 126.13,48.1 126.55,47.68 130.62,47.68 130.8,47.86 140.78,47.86 142.68,49.76 147.28,49.76 149.16,51.64 152.66,51.64 153.83,52.81 167.42,52.81 168.74,54.13 169.61,54.13 170.79,52.96 175.47,52.96 176.65,51.77 189.23,51.77 192.8,55.34 193.77,55.34 200.23,61.8 203.46,61.8 203.61,61.65 v6(203.61,61.43)
  IN4 w0.127: v5(44.34,63.72) 44.34,64.02 44.46,64.14 45.26,64.14 46.26,63.14 46.26,61.72 46.11,61.57 45.89,61.57 v2(45.75,61.71)
  BOTTOM w0.14: v6(203.61,61.43) 203.9,61.71 204.61,61.71 204.73,61.84 205.48,61.84 205.69,61.64 C244.1
INT_DP_TXP0: length 5.6
  TOP w0.14: C10.2 209,62.95 209.1,63.05 209.1,63.56 209.24,63.7 209.45,63.7 209.61,63.53 209.81,63.53 209.98,63.7 210.23,63.7 210.44,63.9 210.44,64.11 210.57,64.24 210.78,64.24 210.94,64.41 210.94,64.61 211.16,64.83 211.77,64.83 211.93,64.66 211.93,64.33 CN1.3
INT_DP_TXP0_C: length 182.9
  TOP w0.14: v6(204.93,62.58) 205.24,62.89 206.35,62.89 206.75,63.29 207.5,63.29 C10.1
  IN2 w0.127: v6(204.93,62.58) 204.65,62.86 200.1,62.86 193.42,56.18 192.35,56.18 189.69,53.51 188.8,52.62 177.03,52.62 175.85,53.79 171.53,53.79 170.35,54.97 166.35,54.97 165.05,53.66 148.06,53.66 147.28,52.88 147.28,51.84 146.08,50.64 142.12,50.64 140.21,48.73 134.67,48.73 134.45,48.96 127.86,48.96 125.44,51.38 123.15,51.38 122.65,51.88 118.82,51.88 117.58,53.12 114.79,53.12 113.04,54.87 106.07,54.87 101.56,59.37 95.14,59.37 92.69,61.82 86.94,61.82 85.73,60.61 82.13,60.61 76.72,66.02 72.4,66.02 71.19,64.81 65.07,64.81 63.65,63.39 52.17,63.39 51.6,63.96 49.02,63.96 v5(48.79,63.74)
  IN4 w0.127: v2(47.69,60.09) 47.69,60.33 47.39,60.62 47.39,61.15 47.67,61.43 47.67,63.56 48.18,64.06 48.6,64.06 48.79,63.87 v5(48.79,63.74)
INT_DP_TXP1: length 5.1
  TOP w0.14: CN1.9 212.41,62.01 210.98,62.01 210.53,61.56 210.32,61.56 v7(209.81,62.06) 209.31,61.56 209,61.56 C13.2
INT_DP_TXP1_C: length 183.6
  TOP w0.14: C13.1 207.63,61.71 206.62,61.71 205.88,60.96 205.21,60.96 v6(204.95,61.22)
  IN2 w0.127: v6(204.95,61.22) 204.95,61.08 205.17,60.86 205.52,60.86 205.83,60.56 205.83,60.02 205.23,59.43 199.05,59.43 194.12,54.5 193.19,54.5 189.61,50.92 175.51,50.92 175.22,50.63 172.73,50.63 172.03,51.33 167,51.33 166.44,51.88 158.38,51.88 157.93,51.44 154.19,51.44 153.27,50.53 150.15,50.53 148.35,48.72 142.93,48.72 141.23,47.03 131.28,47.03 131.1,46.84 125.15,46.84 121.91,50.09 118.23,50.09 117.25,51.06 114.46,51.06 113.06,52.46 105.03,52.46 99.8,57.69 80.71,57.69 77.1,61.3 77.1,61.66 77.1,61.66 77.1,61.79 75.27,63.62 72.6,63.62 72.12,63.14 65.86,63.14 64.4,61.68 49.62,61.68 49.38,61.92 46.3,61.92 46.2,62.02 44.6,62.02 v5(44.37,61.79)
  IN4 w0.127: v2(45.18,60.74) 45.19,60.74 44.85,61.08 44.85,61.97 44.71,62.11 44.49,62.11 44.37,62 v5(44.37,61.79)
INT_DP_TXP2: length 5.4
  TOP w0.14: CN1.15 212.21,59.71 212.21,59.03 211.73,58.55 209.6,58.55 209.27,58.88 C43.2
INT_DP_TXP2_C: length 183.7
  TOP w0.14: C43.1 207.48,59.25 207.21,59.25 206.8,58.84 205.99,58.84 205.8,58.65 v6(205.8,58.44)
  IN2 w0.127: v6(205.8,58.44) 205.8,58.47 206.05,58.73 206.2,58.73 206.38,58.54 206.38,56.24 206.26,56.11 205.55,56.11 205.42,56.24 205.42,57.57 204.19,58.81 199.34,58.81 198.59,58.05 198.59,56.96 198.45,56.82 197.16,56.82 194.33,53.99 193.41,53.99 189.82,50.4 175.74,50.4 175.39,50.04 172.53,50.04 171.94,50.64 160.44,50.64 158.6,48.8 149.86,48.8 149.28,48.21 143.18,48.21 140.86,45.89 139.86,45.89 139.23,46.52 131.63,46.52 131.44,46.33 124.07,46.33 122.82,47.58 122.82,48.24 121.49,49.57 118.01,49.57 117.04,50.55 114.24,50.55 112.84,51.95 104.71,51.95 99.47,57.19 80.5,57.19 76.59,61.09 76.59,61.58 75.06,63.11 72.81,63.11 72.33,62.63 71.41,62.63 67.89,59.11 66.21,59.11 65.54,59.78 58.25,59.78 57.14,60.89 48.96,60.89 48.86,60.98 v5(48.86,61.18)
  IN4 w0.127: v5(48.86,61.18) 48.86,61.03 48.7,60.86 48.24,60.86 48.11,60.74 v2(47.69,60.74)
INT_DP_TXP3: length 3.5
  BOTTOM w0.14: C243.2 206.85,62.03 208.28,62.03 208.44,62.2 CN1.10
INT_DP_TXP3_C: length 185.6
  IN2 w0.127: v6(203.61,62.31) 203.43,62.13 200.1,62.13 193.63,55.67 192.66,55.67 189.09,52.1 176.79,52.1 175.6,53.29 170.92,53.29 169.75,54.46 168.6,54.46 167.28,53.14 153.69,53.14 152.52,51.97 149.02,51.97 147.14,50.09 142.54,50.09 140.64,48.19 130.66,48.19 130.48,48.01 126.69,48.01 126.46,48.23 126.46,49.34 124.95,50.86 122.95,50.86 122.54,51.27 118.7,51.27 117.74,52.24 114.94,52.24 113.54,53.64 106.3,53.64 101.08,58.86 87.57,58.86 86.96,59.47 80.77,59.47 80.17,60.06 80.17,61.84 76.71,65.3 72.64,65.3 72.12,64.79 72.12,64.79 71.63,64.3 65.32,64.3 63.87,62.86 50.1,62.86 49.75,63.2 46.93,63.2 45.66,64.47 44.39,64.47 v5(44.34,64.52)
  IN4 w0.127: v5(44.34,64.52) 44.39,64.47 45.39,64.47 46.59,63.28 46.59,61.58 46.25,61.24 45.93,61.24 v2(45.75,61.06)
  BOTTOM w0.14: v6(203.61,62.31) 203.95,61.98 204.5,61.98 204.62,62.11 205.38,62.11 C243.1
IRQ_SERIRQ: length 100.7
  TOP w0.127: v9(149.39,61.83) 148.42,60.86 R49.2 ; RP4.3 82.49,54.25 82.84,53.9 v4(82.84,53.07) 83.55,52.35 83.55,51.03 83.12,50.6 83.12,49.41 83.55,48.98 84.95,48.98 85.31,48.62 86.45,48.62 86.67,48.85 87.61,48.85 89.06,47.4 91.55,47.4 92.87,46.08 v7(93.63,46.08) 94.07,46.08 94.6,46.61 v4(95.62,46.61)
  IN1 w0.089: v9(135.51,56.98) 134.83,56.98 134.55,57.25 133.18,57.25 132.6,56.67 132.34,56.67 132,57.02 128.09,57.02 121.72,50.65 118.27,50.65 115.95,48.33 105.38,48.33 104.1,47.05 96.68,47.05 96.25,46.61 v4(95.62,46.61) ; v4(82.84,53.07) 82.81,53.04 82.74,53.04 82.36,52.66 v5(82.26,52.66)
  IN2 w0.089: v9(149.39,61.83) 149.6,62.04 149.6,62.65 148.24,64.01 146.72,64.01 146.01,63.3 135.47,63.3 134.78,62.62 134.78,58.37 135.51,57.65 v9(135.51,56.98)
  IN3 w0.089: v5(82.26,52.66) 81.85,53.06 78.49,53.06 77.28,51.85 76.36,51.85 76.16,52.05 76.16,52.38 76.32,52.54 76.32,52.88 v2(76.18,53.01)
  BOTTOM w0.127: v2(76.18,53.01) 76.08,53.01 U16.T4
IRQ_SERIRQ_TPM: length 4.9
  TOP w0.127: U6.27 149.17,56.82 148.42,57.56 R49.1 148.74,57.98 148.96,58.2 v7(148.96,59.77)
KB_BACKLITE_EN: length 87.9
  TOP w0.127: v9(181.26,17.86) 181.26,15.98 v7(180.63,15.35) 179.89,14.61 Q21.2 ; U4.K6 v4(137.61,55.48)
  IN1 w0.089: v9(145.07,31.58) 145.07,34.35 143.14,36.28 139.24,36.28 137.32,38.19 137.32,38.89 136.18,40.04 136.18,43.77 135.01,44.94 135.01,49.13 136.71,50.83 136.71,51.62 136.23,52.1 136.23,52.84 136.51,53.12 136.51,53.27 136.82,53.57 137.14,53.57 137.78,54.22 137.78,55.31 v4(137.61,55.48)
  IN2 w0.089: v9(145.07,31.58) 145.07,31.5 146.01,30.56 147.74,30.56 151.09,27.21 151.09,25.33 151.17,25.25 151.17,21.19 153.4,18.95 162.34,18.95 164.53,21.14 171.69,21.14 174.2,18.62 175.83,18.62 177.71,16.74 180.15,16.74 v9(181.26,17.86)
KB_DET#: length 94.6
  TOP w0.127: v4(138.9,17.12) 138.3,16.53 JKB1.1
  IN1 w0.089: v4(138.9,17.12) 140.01,18.24 140.01,24.64 138.64,26.02 138.64,28.46 136.75,30.34 136.75,37.76 136.37,38.14 136.37,38.98 135.43,39.92 v9(135.43,41.71)
  IN2 w0.089: v9(135.43,41.71) 135.34,41.61 133.56,41.61 133.13,42.04 126.93,42.04 126.55,41.66 125.59,41.66 124.88,42.37 120.91,42.37 120.2,43.08 117.84,43.08 116.55,41.79 108.47,41.79 107.68,42.58 107.68,44.66 105.9,46.44 102.17,46.44 98.31,50.3 89.79,50.3 89.28,50.8 86.17,50.8 86.01,50.65 84.46,50.65 83.22,51.9 83.22,52.56 v5(83.12,52.66)
  IN3 w0.089: v5(83.12,52.66) 82.81,52.66 v2(82.74,52.58)
  BOTTOM w0.127: R291.1 82.42,52.2 TP86.1 81.08,52.2 79.78,50.91 78.91,50.91 78.75,50.75 U16.Y1
KB_LED_DET: length 137.3
  TOP w0.127: v7(78.06,62.59) 78.09,62.59 v4(78.5,62.18) 78.32,62.01 R28.1
  IN1 w0.089: v9(107.66,58.37) 107.63,58.4 106.05,58.4 105.32,59.14 87.82,59.14 87.38,59.57 82.36,59.57 82.03,59.24 81.23,59.24 80.73,59.75 80.73,60.18 78.72,62.18 v4(78.5,62.18) 78.29,61.98 v5(78.29,61.7)
  IN2 w0.089: v9(107.66,58.37) 108.44,57.59 113.42,57.59 115.5,55.5 117.74,55.5 118.17,55.94 123.3,55.94 v5(123.37,55.86)
  IN3 w0.089: v2(170.14,20.78) 168.36,22.56 168.36,30.28 166.81,31.83 166.81,32.41 166.94,32.54 166.94,37.17 165.47,38.64 160.56,38.64 158.84,40.37 158.84,42.27 157.36,43.74 155.64,43.74 154.7,42.8 v2(153.48,42.8)
  IN4 w0.089: v5(123.37,55.86) 123.42,55.91 v2(124.11,55.91) ; v5(78.29,61.7) v2(78.57,61.98)
  BOTTOM w0.089: 78.19,59.52 77.81,59.52 77.63,59.34 76.46,59.34
  BOTTOM w0.127: 78.19,59.52 78.57,59.9 v2(78.57,61.98) ; R391.1 R392.1 ; U16.L6 74.73,55.93 74.8,56 74.8,59.05 75.22,59.47 76.34,59.47 76.46,59.34 ; v2(124.11,55.91) 125,56.8 128.25,56.8 128.86,56.19 128.86,55.35 127.98,54.46 127.98,53.6 128.23,53.34 128.71,53.34 129.49,54.12 136.52,54.12 147.41,43.24 153.04,43.24 v2(153.48,42.8)
KSI0: length 55.3
  TOP w0.127: JKB1.9 144.7,17.64 144.84,17.78 EC32.1 145.15,18.14 145.32,18.32 145.32,18.83 146.24,19.74 v7(147.2,19.74) 147.53,20.07 151.37,20.07 152.26,19.18 v4(152.33,19.18)
  IN1 w0.089: v4(152.33,19.18) 152.08,19.44 152.08,19.74 151.88,19.94 151.88,24.64 152.43,25.2 152.43,28.88 153.48,29.93 153.48,32.9 149.79,36.58 149.11,36.58 144.38,41.3 143.6,41.3 142.21,42.69 142.21,49.86 141.96,50.1 141.96,53.53 141.21,54.28 141.21,55.43 140.66,55.98 v4(140.51,55.98)
KSI1: length 58.7
  TOP w0.127: JKB1.7 143.1,17.26 142.94,17.43 EC30.1 143.29,18.14 143.39,18.24 143.39,18.65 145.6,20.86 v7(149.29,20.86) 151.9,20.86 v4(153.12,19.64) ; v4(141.69,55.96) 141.54,55.81 141.18,55.81 U4.J13
  IN1 w0.089: v4(141.69,55.96) 141.69,55.81 142.5,55 142.5,54.11 142.73,53.88 142.73,50.47 143.02,50.18 143.02,43.56 143.34,43.24 143.8,43.24 145.04,41.99 146.57,41.99 149.51,39.04 149.51,38.04 154.28,33.28 154.28,29.53 153.34,28.59 153.34,24.97 152.79,24.41 152.79,20.43 153.12,20.1 v4(153.12,19.64)
KSI2: length 53.7
  TOP w0.127: v4(148.8,22.43) 148.55,22.43 v7(148.14,22.03) 145.98,22.03 143.19,19.23 141.89,19.23 141.46,18.8 141.46,18.27 141.34,18.14 EC28.1 140.93,17.99 141.5,17.42 JKB1.5
  IN1 w0.089: v9(138.24,51.31) 138.14,51.21 138.14,49.64 137.78,49.28 137.78,40.95 139.76,38.97 140.95,38.97 141.56,38.36 143.32,38.36 147.89,33.79 147.89,31.2 149.36,29.72 149.36,26.75 148.8,26.19 v4(148.8,22.43)
  IN2 w0.089: v9(138.24,51.31) 138.41,51.49 138.62,51.49 139.18,52.05 139.18,55.22 139.3,55.35 139.3,55.68 v9(139.01,55.98)
KSI3: length 56.2
  TOP w0.127: JKB1.8 EC31.1 144.13,18.14 144.31,18.32 144.31,18.8 v7(145.53,20.02) 145.83,20.32 151.6,20.32 v4(152.36,19.56)
  IN1 w0.089: v4(152.36,19.56) 152.36,19.77 152.16,19.97 152.16,24.64 152.65,25.14 152.65,28.76 153.68,29.78 153.68,33.03 149.87,36.83 149.18,36.83 144.51,41.51 143.67,41.51 142.41,42.77 142.41,49.96 142.15,50.21 142.15,53.62 141.41,54.36 141.41,55.57 v4(140.51,56.48)
KSI4: length 58.4
  TOP w0.127: EC20.1 143.52,20.07 v4(143.01,19.56) 141.84,19.56 141.23,18.95 140.73,18.95 140.52,18.75 140.52,17.61 v7(140.8,17.33) 140.7,17.23 JKB1.4
  IN1 w0.089: v9(137.06,52.94) 137.27,52.94 137.43,52.78 137.43,52.08 137.34,51.99 137.34,49.96 135.85,48.47 135.85,45.34 136.99,44.2 136.99,40.55 140.22,37.32 143.22,37.32 146.09,34.45 146.09,30.92 148.54,28.46 148.54,27.17 147.91,26.54 147.91,20.58 146.9,19.56 v4(143.01,19.56)
  IN2 w0.089: v9(137.06,52.94) 137.15,53.03 137.23,53.03 137.44,53.24 137.44,55.72 137.53,55.81 137.53,56.49 137.61,56.57 138.91,56.57 v9(139.01,56.48)
KSI5: length 53.2
  TOP w0.127: v9(139.8,56.24) 139.56,56.48 U4.H10 ; JKB1.6 142.3,17.18 142,17.48 EC29.1 142.13,18.14 142.4,18.42 142.4,18.8 142.58,18.98 143.32,18.98 145.73,21.39 v7(147.03,21.39) 148.27,21.39 v4(148.8,21.92)
  IN1 w0.089: v4(148.8,21.92) 149.08,22.2 149.08,26.19 149.57,26.67 149.57,29.82 148.1,31.28 148.1,33.9 143.44,38.56 141.69,38.56 140.95,39.3 140.07,39.3 138.01,41.35 138.01,49.23 138.34,49.56 138.34,50.78 v9(138.87,51.31)
  IN2 w0.089: v9(138.87,51.31) 138.87,51.44 139.38,51.95 139.38,55.1 139.58,55.3 139.58,55.78 139.51,55.86 139.51,55.95 139.79,56.24 v9(139.8,56.24)
KSI6: length 62.1
  TOP w0.127: JKB1.3 139.9,16.35 140.27,16.72 140.27,18.98 140.8,19.51 v7(141.01,19.51) 141.31,19.82 142.25,19.82 v4(142.45,20.02) EC19.1 ; v9(141.34,56.2) 141.34,56.25 141.08,56.48 U4.H13
  IN1 w0.089: v9(136.87,50.17) 135.44,48.75 135.44,45.11 136.58,43.97 136.58,40.39 137.75,39.22 137.75,38.33 139.35,36.73 143.24,36.73 145.63,34.35 145.63,30.79 148.12,28.3 148.12,27.28 147.48,26.65 147.48,20.71 146.82,20.05 142.48,20.05 v4(142.45,20.02)
  IN2 w0.089: v9(136.87,50.17) 137.07,49.97 139.38,49.97 141.67,52.25 141.67,52.73 142.76,53.83 143.19,53.83 143.44,54.08 143.44,54.74 143.32,54.87 142.91,54.87 141.58,56.2 v9(141.34,56.2)
KSI7: length 58.9
  TOP w0.127: JKB1.2 139.1,16.34 139.53,16.77 v7(139.53,17.33) 140.01,17.81 140.01,19.28 140.88,20.15 v4(141.44,20.15) EC18.1 ; U4.G9 138.77,56.98 v9(138.64,56.85)
  IN1 w0.089: v4(141.44,20.15) 141.59,20.3 146.8,20.3 147.28,20.78 147.28,26.73 147.87,27.33 147.87,28.27 145.4,30.74 145.4,34.29 143.16,36.53 139.28,36.53 137.55,38.26 137.55,38.94 136.38,40.11 136.38,43.85 135.24,44.99 135.24,49.08 136.91,50.76 136.91,51.7 136.43,52.18 136.43,52.66 136.7,52.92 136.7,53.05 136.94,53.29 v9(137.12,53.29)
  IN2 w0.089: v9(137.12,53.29) 137.23,53.41 137.23,55.86 137.35,55.97 137.35,56.6 137.5,56.75 138.55,56.75 v9(138.64,56.85)
KSO0: length 49.5
  TOP w0.127: EC41.1 152.86,17.35 v7(152.33,17.35) 152.11,17.35 v4(151.32,16.57) 151.42,16.46 151.72,16.46 151.9,16.29 JKB1.18
  IN1 w0.089: v4(138.51,54.48) 139.28,53.71 139.28,52.38 139.71,51.95 139.71,50.73 139.4,50.42 139.4,41.71 139.8,41.32 140.54,41.32 142.78,39.07 143.52,39.07 148.51,34.08 148.51,31.44 149.98,29.97 149.98,26.5 149.51,26.04 149.51,21.54 149.16,21.19 149.16,18.06 150.38,16.84 151.04,16.84 v4(151.32,16.57)
KSO1: length 63.4
  TOP w0.127: EC39.1 151.65,18.14 v7(150.86,17.35) 150.3,16.79 JKB1.16 150.3,15.85 v4(150.3,15.09) ; v9(138.22,56.3) 138.22,56.22 138.01,56.01 U4.J7
  IN1 w0.089: v9(137.08,52.2) 137.15,52.13 137.15,50.05 135.65,48.54 135.65,45.24 136.79,44.1 136.79,40.47 140.14,37.11 143.14,37.11 145.83,34.42 145.83,30.87 148.32,28.38 148.32,27.21 147.69,26.58 147.69,20.63 146.9,19.84 142.88,19.84 142.68,19.64 142.68,19.16 144.79,17.05 148.35,17.05 v4(150.3,15.09)
  IN2 w0.089: v9(138.22,56.3) 138.06,56.14 138.06,55.71 137.88,55.52 137.88,53.14 137.34,52.6 137.34,52.43 137.11,52.2 v9(137.08,52.2)
KSO2: length 49.3
  TOP w0.127: JKB1.17 151.1,16.22 v4(150.76,16.57) 151.04,16.84 151.11,16.84 151.61,17.34 151.61,17.4 152.35,18.14 EC40.1 ; v7(139.18,52.94) 138.76,53.35 v4(138.76,53.39) 139.01,53.64 U4.N9
  IN1 w0.089: v4(150.76,16.57) 150.38,16.57 148.83,18.11 148.83,21.29 149.31,21.77 149.31,26.12 149.76,26.57 149.76,29.89 148.32,31.34 148.32,33.96 143.42,38.87 142.68,38.87 140.54,41.01 139.82,41.01 139.23,41.61 138.9,41.61 138.7,41.8 138.7,50.13 139.51,50.93 139.51,51.87 139.07,52.3 139.07,53.08 v4(138.76,53.39)
KSO3: length 45.3
  TOP w0.127: EC38.1 150.71,17.99 v4(150.33,17.61) 149.5,16.78 JKB1.15
  IN1 w0.089: v4(150.33,17.61) 149.95,17.99 149.95,19.23 150.2,19.49 150.2,25.51 150.58,25.89 150.58,30.26 149.11,31.73 149.11,34.35 143.77,39.68 143.01,39.68 140.62,42.07 140.62,49.16 140.44,49.34 140.44,51.54 139.5,52.48 139.5,53.83 139.07,54.26 139.07,54.41 v4(139.01,54.48)
KSO4: length 48.2
  TOP w0.127: EC34.1 v4(146.8,18.14) 146.8,17.48 v7(146.67,17.35) 146.3,16.98 JKB1.11
  IN1 w0.089: v9(138.48,52.15) 138.48,52.15 138.42,52.15 138.07,51.8 137.83,51.8 137.72,51.69 137.72,49.78 137.4,49.46 137.4,40.7 140.27,37.83 143.27,37.83 146.59,34.5 146.59,30.97 148.96,28.6 148.96,26.95 148.32,26.32 148.32,19.69 146.81,18.18 146.81,18.15 v4(146.8,18.14)
  IN2 w0.089: v9(138.46,55.48) 138.46,52.89 138.22,52.66 138.22,52.32 138.39,52.15 v9(138.48,52.15)
KSO5: length 49
  TOP w0.127: v4(145.83,18.14) 145.83,17.79 v7(145.4,17.35) 145.5,17.25 JKB1.10 ; U4.J8 v9(138.46,55.98)
  IN1 w0.089: v9(138.48,52.51) 138.45,52.51 138.21,52.26 138.21,52.23 137.98,52 137.75,52 137.53,51.77 137.53,49.87 137.19,49.53 137.19,40.62 140.19,37.62 143.19,37.62 146.36,34.45 146.36,30.92 148.75,28.53 148.75,27.08 148.12,26.45 148.12,20.42 v4(145.83,18.14)
  IN2 w0.089: v9(138.46,55.98) 138.73,55.7 138.73,52.75 v9(138.48,52.51)
KSO6: length 45.8
  TOP w0.127: v4(150.78,19.23) 150.78,19.08 150.61,18.9 149.34,18.9 149.23,18.8 149.23,18.37 149.01,18.14 EC36.1 148.53,18.14 147.94,17.56 v7(147.94,17.35) 147.9,17.31 JKB1.13 ; U4.N10 139.66,53.83 139.66,53.17 v4(140.04,52.79)
  IN1 w0.089: v4(140.04,52.79) 140.82,52 140.82,49.52 141.01,49.33 141.01,42.24 143.16,40.09 143.93,40.09 149.51,34.5 149.51,31.88 150.99,30.41 150.99,25.71 150.61,25.33 150.61,19.46 150.78,19.28 v4(150.78,19.23)
KSO7: length 47.1
  TOP w0.127: JKB1.12 147.1,17 147.2,17.1 147.2,17.89 147.46,18.14 EC35.1 148.12,18.14 148.22,18.24 148.22,19.08 v7(148.68,19.54) 150.1,19.54 v4(150.4,19.23)
  IN1 w0.089: v4(139.51,54.48) 139.51,54.33 139.77,54.08 139.77,52.63 140.63,51.76 140.63,49.43 140.82,49.24 140.82,42.15 143.09,39.88 143.85,39.88 149.31,34.42 149.31,31.81 150.78,30.33 150.78,25.79 150.4,25.4 v4(150.4,19.23)
KSO8: length 44.8
  TOP w0.127: U4.N11 140.01,53.33 v4(140.04,53.29) ; JKB1.14 148.7,16.84 v7(149.21,17.35) 149.72,17.86 EC37.1 150.25,18.14 v4(150.25,18.14)
  IN1 w0.089: v4(150.25,18.14) 151.06,18.95 151.06,19.36 150.81,19.61 150.81,25.25 151.2,25.64 151.2,30.48 149.72,31.96 149.72,34.57 144,40.29 143.24,40.29 141.2,42.33 141.2,49.44 141.01,49.63 141.01,52.32 v4(140.04,53.29)
KSO9: length 59.5
  TOP w0.127: EC47.1 159.11,17.45 v6(158.68,17.45) 158.25,17.45 157.68,16.88 157.07,16.88 156.7,16.51 JKB1.24 156.7,15.85 v4(156.7,15.14)
  IN1 w0.089: v9(138.49,51.77) 138.34,51.77 138.16,51.59 137.96,51.59 137.92,51.56 137.92,49.7 137.59,49.37 137.59,40.84 139.84,38.59 141.03,38.59 141.59,38.03 143.34,38.03 146.8,34.57 146.8,32.11 147.66,31.25 147.66,31.12 149.17,29.61 149.17,26.86 148.52,26.22 148.52,18.11 150.96,15.68 156.17,15.68 v4(156.7,15.14)
  IN2 w0.114: v9(138.49,51.77) 138.96,52.24 138.96,55.43 v9(139.01,55.48)
KSO10: length 54.6
  TOP w0.127: EC49.1 161.83,18.01 v7(161.22,17.4) 160.56,16.74 158.58,16.74 v4(158.4,16.57) 158.3,16.46 JKB1.26 ; U4.N12 140.64,53.85 140.64,53.21 v4(141.06,52.79)
  IN1 w0.089: v4(141.06,52.79) 141.2,52.64 141.2,49.72 141.4,49.53 141.4,42.41 143.32,40.49 144.08,40.49 149.92,34.65 149.92,32.03 151.41,30.55 151.41,25.55 151.01,25.15 151.01,19.69 151.28,19.43 151.28,17.49 152.72,16.05 157.89,16.05 v4(158.4,16.57)
KSO11: length 53
  TOP w0.127: JKB1.25 157.5,16.42 v4(157.64,16.57) 157.9,16.57 158.33,17 159.55,17 v7(159.95,17.4) 160.69,18.14 160.81,18.14 EC48.1 ; U4.N13 141.01,53.34 v4(141.06,53.29)
  IN1 w0.089: v4(141.06,53.29) 141.39,52.96 141.39,49.83 141.6,49.63 141.6,42.49 143.39,40.7 144.15,40.7 150.12,34.73 150.12,32.14 151.64,30.62 151.64,25.45 151.27,25.07 151.27,19.71 151.47,19.51 151.47,17.57 152.8,16.24 157.32,16.24 v4(157.64,16.57)
KSO12: length 48.2
  TOP w0.127: EC42.1 154.3,17.72 153.97,17.72 v7(153.6,17.35) 153.53,17.35 v4(153.07,16.9) 152.7,16.53 JKB1.19 ; U4.M13 v4(141.69,54.48)
  IN1 w0.089: v4(141.69,54.48) 141.69,54.36 142.35,53.71 142.35,50.3 142.61,50.03 142.61,43.29 143.2,42.7 143.6,42.7 149.26,37.04 149.97,37.04 153.87,33.15 153.87,29.67 152.95,28.76 152.95,25.16 152.38,24.59 152.38,20.15 152.64,19.89 152.64,17.33 v4(153.07,16.9)
KSO13: length 52.7
  TOP w0.127: JKB1.22 155.1,16.26 v4(155.56,16.72) 155.56,16.74 v7(156.15,17.33) 156.65,17.84 157.06,17.84 157.37,18.14 EC45.1
  IN1 w0.089: v4(140.51,54.98) 140.52,54.98 140.8,54.69 140.8,54.13 141.58,53.35 141.58,49.92 141.8,49.7 141.8,42.56 143.46,40.9 144.23,40.9 150.33,34.8 150.33,34.47 150.94,33.86 151.93,33.86 153.07,32.72 153.07,30.13 151.98,29.04 151.98,25.43 151.47,24.92 151.47,19.79 151.67,19.59 151.67,17.64 152.88,16.43 155.27,16.43 v4(155.56,16.72)
KSO14: length 52
  TOP w0.127: v4(141.69,55.07) 141.56,55.07 141.47,54.98 U4.L13 ; JKB1.23 155.9,16.6 v4(155.99,16.69) 156.3,16.69 157.01,17.4 v7(157.41,17.4) 157.72,17.4 158.46,18.14 EC46.1
  IN1 w0.089: v4(141.69,55.07) 141.69,54.87 141.97,54.59 141.97,54.36 142.54,53.8 142.54,50.39 142.82,50.11 142.82,43.41 143.3,42.93 143.8,42.93 144.94,41.79 146.47,41.79 149.16,39.1 149.16,38.13 154.06,33.23 154.06,29.59 153.15,28.67 153.15,25.05 152.59,24.49 152.59,20.22 152.84,19.97 152.84,19.37 155.14,17.07 155.61,17.07 v4(155.99,16.69)
KSO15: length 52.6
  TOP w0.127: JKB1.21 154.3,16.35 154.72,16.77 v4(155,16.77) 155.03,16.77 155.41,17.15 155.41,17.35 155.9,17.85 156.08,17.85 156.38,18.14 EC44.1
  IN1 w0.089: v4(140.51,55.48) 140.52,55.48 141.01,55 141.01,54.21 141.77,53.44 141.77,50.01 142,49.78 142,42.63 143.52,41.11 144.3,41.11 149.06,36.35 149.72,36.35 150.53,35.54 150.53,34.65 151.04,34.14 151.93,34.14 153.27,32.8 153.27,30.05 152.23,29 152.23,25.35 151.67,24.79 151.67,19.87 151.86,19.68 151.86,17.72 152.96,16.62 154.85,16.62 v4(155,16.77)
KSO16: length 50.9
  TOP w0.127: v4(142.28,55.63) 142.12,55.48 U4.K13 ; v4(155.74,18.14) 155.66,18.14 v7(154.87,17.35) 154.39,17.35 153.5,16.46 JKB1.20
  IN1 w0.089: v4(142.28,55.63) 142.33,55.63 142.73,55.22 142.73,54.18 142.92,54 142.92,50.57 143.21,50.28 143.21,43.65 143.42,43.44 143.95,43.44 145.2,42.19 146.72,42.19 149.79,39.12 149.79,38.05 154.47,33.38 154.47,29.39 153.57,28.49 153.57,24.91 152.99,24.34 152.99,20.5 153.4,20.1 153.4,19.69 154.95,18.14 v4(155.74,18.14)
LATCH: length 28.9
  TOP w0.127: C9.1 128,63.61 127.82,63.43 127.82,59.92 126.78,58.88 ; C9.1 128.21,63.35 Q4.6 ; C9.1 128.86,63.22 Q4.5 ; Q5.3 121.99,55.67 121.52,55.67 120.62,54.77 D7.1 ; Q5.3 123.25,56.19 124.44,57.38 124.44,59.62 D3.1 125.66,60 126.78,58.88 ; Q5.3 122.51,56.2 R41.2 121.55,57.61 v7(121.45,57.51) 120.48,57.51 120.04,57.95 120.04,59.83 D2.2 ; 126.78,58.88 126.78,57.18 126.43,56.82 D5.1
LCD_BAK: length 75.8
  TOP w0.127: v4(147.52,51.04) 147.52,52.02 146.07,53.47 142.86,53.47 141.79,52.4 138.8,52.4 138.41,52.8 138.41,53.87 U4.N8
  IN1 w0.089: v4(147.52,51.04) 147.82,51.04 148.75,51.97 v9(148.75,60.28)
  IN2 w0.089: v5(192.77,56.89) 192.64,57.02 189.2,57.02 188.7,57.52 180.3,57.52 179.8,57.02 177.06,57.02 176.18,57.89 175.7,57.89 174.46,59.14 154.59,59.14 154.31,58.86 150.13,58.86 149.01,59.98 149.01,60.02 v9(148.75,60.28)
  IN3 w0.089: v2(190.33,61.93) 193.05,59.21 193.05,57.18 v5(192.77,56.89)
  BOTTOM w0.127: v7(191.25,61.98) 191.2,61.94 PR164.1
LCD_CE: length 145.1
  TOP w0.127: v4(83.45,50.37) 83.58,50.5 R98.1 84.38,50.04 85.46,50.04 TP21.1
  IN1 w0.089: v5(82.2,51.36) 82.2,51.19 83.02,50.37 v4(83.45,50.37)
  IN2 w0.089: v5(197.09,52.61) 196.97,52.61 192.9,48.54 192.26,48.54 189.87,46.16 184.53,46.16 184.26,46.42 179.97,46.42 178.49,44.94 172.3,44.94 171.25,43.89 166.89,43.89 166.28,44.51 151.85,44.51 151.27,43.92 145.63,43.92 145.4,43.69 145.15,43.69 142.73,41.28 141.13,41.28 140.64,40.78 138.27,40.78 137.65,41.41 131.84,41.41 131.52,41.09 128.91,41.09 128.48,40.66 125.14,40.66 124.42,41.38 117.51,41.38 116.98,40.85 108.07,40.85 106.69,42.22 106.69,44.1 105.39,45.39 101.68,45.39 98.28,48.8 97.19,48.8 96.63,49.36 89.38,49.36 89.05,49.69 83.55,49.69 82.2,51.03 v5(82.2,51.36)
  IN3 w0.089: v2(75.66,52.21) 75.66,51.64 75.98,51.31 78.98,51.31 79.41,50.88 81.72,50.88 v5(82.2,51.36)
  IN4 w0.089: v5(197.09,52.61) 196.49,53.21 v2(192.86,53.21)
  BOTTOM w0.127: U16.U4 v2(75.66,52.21) ; J1.20 192.85,53.21 v2(192.86,53.21)
LCD_DBC: length 143
  IN3 w0.089: v8(179.41,40.54) 179.28,40.42 168.89,40.42 161.35,47.96 155.86,47.96 155.79,47.88 144.84,47.88 141.49,44.54 138.28,44.54 137.37,45.45 136.62,45.45 136.38,45.21 136.38,44.36 135.4,43.39 131.81,43.39 130.26,44.94 115.2,44.94 111.31,48.82 103.85,48.82 102.19,50.47 91.5,50.47 90.74,49.71 90.1,49.71 89.65,49.26 89.24,49.26 88.17,50.32 87.11,50.32 86.6,49.81 v2(86.6,49.53) 85.64,49.53 85.46,49.71 78.52,49.71 77.91,50.32 v2(77.1,50.32)
  IN4 w0.089: v8(179.41,40.54) 179.66,40.8 181.32,40.8 181.99,41.47 188.74,41.47 190.23,42.96 192.31,42.96 193.05,43.69 193.05,44.2 193.49,44.65 193.49,46.65 195.77,48.93 v2(195.77,51.24)
  BOTTOM w0.127: U16.Y3 v2(77.1,50.32) ; R302.1 86.12,50.63 86.32,50.83 86.93,50.83 87.23,50.53 87.69,50.53 87.97,50.25 TP96.1 87.87,49.84 87.11,49.84 86.8,49.53 v2(86.6,49.53) ; J1.14 195.85,51.32 v2(195.77,51.24)
LCD_PWM: length 191.1
  TOP w0.127: v9(80.15,67.34) 78.65,67.34 73.19,61.88 v4(73.19,61.05)
  IN1 w0.089: v9(80.15,67.34) 79.63,66.83 79.63,66.35 79.29,66.01 78.03,66.01 77.59,66.45 73.2,66.45 71.58,64.83 64.95,64.83 63.73,63.61 53.3,63.61 53.07,63.83 53.07,65.59 54.85,67.37 v5(55.64,67.37) ; v5(190.92,42.37) 187.46,45.83 187.46,56.88 188.88,58.3 v9(188.88,63.83) ; v5(73.43,60.81) v4(73.19,61.05)
  IN2 w0.089: v9(188.88,63.83) 188.88,63.89 187.35,65.42 174.9,65.42 174.08,66.25 167.91,66.25 165.17,63.5 155.46,63.5 151.58,67.38 138.66,67.38 138.42,67.14 127.77,67.14 126.95,66.31 125.15,66.31 123.13,64.3 121.66,64.3 121.17,63.81 118.32,63.81 117.89,64.24 110.14,64.24 106.8,67.59 93.12,67.59 92.11,66.58 87.77,66.58 87,67.34 v9(80.15,67.34)
  IN4 w0.089: v2(73.12,61.07) 73.17,61.07 v5(73.43,60.81) ; v5(55.64,67.37) v2(51.6,67.37) ; v5(190.92,42.37) v2(191.25,42.37)
  BOTTOM w0.127: R258.2 v7(51.01,67.16) 51.22,67.37 v2(51.6,67.37)
LCD_PWM_EC: length 73.9
  TOP w0.127: U4.N6 137.51,53.26 138.69,52.07 142.35,52.07 v7(142.66,51.77) 143.16,51.27 v9(143.21,51.27)
  IN1 w0.089: v5(189.75,40.72) 189.75,41.28 186.32,44.71 186.32,55.1 183.58,57.84 180.12,57.84 179.08,56.8 v9(179.08,54.64)
  IN2 w0.089: v9(179.08,54.64) 172.09,54.64 170.93,55.81 165.67,55.81 164.4,54.54 147.28,54.54 144.54,51.8 143.73,51.8 v9(143.21,51.27)
  IN4 w0.089: v5(189.75,40.72) v2(190.08,40.72)
  BOTTOM w0.127: v2(190.08,40.72) 190.1,40.7 D24.2
LCD_PWM_IN: length 13.1
  BOTTOM w0.254: J1.15 195.35,51.1 195.01,50.75 194.29,50.75 193.96,50.42 193.96,47.27 v7(193.28,46.59) 193.28,45.37 192.62,44.71 R330.1 192.37,44.08 193.38,43.07 193.38,41.38 D24.3
LCD_PWM_OUT: length 15.8
  TOP w0.127: PR7.1 191.64,65.38 v6(191.98,65.03)
  BOTTOM w0.127: v6(191.98,65.03) 193,64.01 193,59.52 v7(192.11,58.63) 193.35,57.39 J1.19
LCD_TST: length 65.1
  TOP w0.127: v4(185.38,51.44) v7(187.72,51.44) 190.18,53.9 D9.2
  IN1 w0.089: v9(142.83,62.54) 141.54,62.54 140.09,61.09 140.09,60.56 139.51,59.98 v4(139.51,59.48) ; v5(184.9,54.94) 185.38,54.46 v4(185.38,51.44)
  IN2 w0.089: v9(142.83,62.54) 146.77,62.54 147.58,61.73 147.58,60.61 149.74,58.45 154.62,58.45 154.9,58.73 174.28,58.73 175.52,57.48 176.03,57.48 177.05,56.47 v5(179.49,56.47)
  IN4 w0.089: v5(179.49,56.47) 180.17,55.78 184.06,55.78 v5(184.9,54.94) 185.58,54.26 v2(185.58,54.18)
  BOTTOM w0.127: v2(185.58,54.18) 185.58,53.09 185.85,52.82 J1.34
LED#2: length 9.2
  BOTTOM w0.127: CN4.16 181.27,33.65 181.7,33.23 182.33,33.23 182.71,33.61 182.71,37.81 182.08,38.44 TP122.1
LED_PWM: length 14.9
  TOP w0.254: v6(175.22,13.42) 175.4,13.59 Q21.3
  IN2 w0.254: v6(167.73,18.11) 168.23,18.11 169.5,16.84 170.88,16.84 171.71,16.01 171.71,15.22 172.12,14.81 173.82,14.81 v6(175.22,13.42)
  BOTTOM w0.254: v6(167.73,18.11) 167.6,17.99 166.86,17.99 166.65,18.2 J2.1
LID_SW#: length 160.3
  TOP w0.127: v7(191.12,18.47) 191.35,18.7 C167.1 ; R77.1 v4(197.44,52.96) ; U4.C2 v4(135.51,58.85) ; C167.1 EC22.1 192.36,18.94 v6(192.85,18.45) ; C167.1 R223.2
  IN1 w0.089: v9(130.21,58.6) 130.46,58.86 131.02,58.86 131.43,59.26 134.36,59.26 134.94,58.68 135.29,58.68 135.46,58.85 v4(135.51,58.85) ; v9(132,53.32) 132,53.07 131.15,52.23 131.15,51.67 131.56,51.26 131.56,47.53 130.92,46.89 130.92,39.93 131.63,39.22 131.63,37.55 130.9,36.81 v9(130.9,34.24) ; v9(201.76,27.39) 201.76,30.56 202.52,31.32 202.52,35.46 202.27,35.72 201.43,35.72 201.23,35.92 201.23,38.38 201.51,38.66 201.51,42.14 201.18,42.47 201.18,47.55 198.99,49.74 198.99,52.4 198.43,52.96 v4(197.44,52.96)
  IN2 w0.089: v9(130.9,34.24) 130.9,32.62 133.36,30.15 142.2,30.15 145.77,33.72 152.8,33.72 154.37,32.16 154.37,31.4 155.25,30.51 166.76,30.51 167.45,31.2 168.64,31.2 178.74,21.09 178.74,20.31 180.1,18.95 185.81,18.95 186.06,18.7 190,18.7 190.71,17.99 192.38,17.99 v6(192.85,18.45) 192.85,18.42 193.66,17.61 198.08,17.61 200.52,20.05 200.52,21.37 201.76,22.61 v9(201.76,27.39) ; v9(132,53.32) 131.7,53.03 131.34,53.03 130.21,54.16 v9(130.21,58.6)
  BOTTOM w0.127: CN6.5 v6(192.85,18.45)
LPC_CLK_0: length 5.8
  TOP w0.127: v4(68.54,42.51) 69.44,42.51 v7(69.45,42.5)
  IN1 w0.089: v5(71.38,43.57) 70.33,42.51 v4(68.54,42.51)
  IN4 w0.089: v2(71.05,43.57) v5(71.38,43.57)
  BOTTOM w0.089: U16.AN15 70.09,43.31
  BOTTOM w0.127: 70.09,43.31 70.8,43.31 v2(71.05,43.57)
LPC_CLK_1: length 8.3
  TOP w0.127: v7(67.52,39.45) 68.53,39.45 R158.1 68.61,39.46 69.31,40.16 R154.1 EC3.1 69.67,41.3 v4(70.01,41.64)
  IN1 w0.089: v4(70.01,41.64) 70.34,41.64 v5(71.71,43.01)
  IN4 w0.089: v2(71.38,43.01) v5(71.71,43.01)
  BOTTOM w0.089: U16.AP15 70.09,42.66
  BOTTOM w0.127: v2(71.38,43.01) 71.04,42.66 70.09,42.66
LPC_CLK_DEBUG: length 143
  TOP w0.127: R240.2 188.69,15.07 v6(188.95,15.32) ; R154.2 71.36,40.16 v7(71.49,40.03)
  IN1 w0.089: v9(173.82,17.23) 172.78,16.18 170.32,16.18 169.83,15.7 169.83,13.29 168.04,11.49 143.77,11.49 141.39,13.87 134.91,13.87 131.05,17.73 120.46,17.73 117.14,21.05 97.51,21.05 90.62,27.94 81.92,27.94 76.79,33.08 73.74,33.08 73.24,33.58 71.36,33.58 v9(70.83,34.12)
  IN2 w0.089: v9(70.83,34.12) 70.06,34.12 68.82,35.36 68.82,39.48 69.5,40.16 v9(70.44,40.16) ; v9(173.82,17.23) 175.57,17.23 177.84,14.97 188.07,14.97 188.43,15.32 v6(188.95,15.32)
LPC_CLK_DEBUG_R: length 10.6
  TOP w0.127: R240.1 186.4,15.07 v7(186.09,15.37) v6(185.38,16.08)
  BOTTOM w0.127: v6(185.38,16.08) 184.46,17 184.46,19.64 183.89,20.21 181.32,20.21 181.25,20.15 CN4.70
LPC_CLK_EC: length 100.9
  TOP w0.127: R139.2 68.54,41.22 68.42,41.1 EC4.1 ; v9(69.05,40.8) 68.84,40.59 EC4.1 ; v7(66.25,40.09) 67.91,40.09 EC4.1
  IN1 w0.089: v9(71.46,34.24) 74.3,34.24 74.79,33.76 76.95,33.76 81.8,28.91 92.83,28.91 95.29,31.37 95.29,39.58 95.84,40.14 96.28,40.14 97.75,41.61 100.19,41.61 102.58,44 105.52,44 106.99,42.53 106.99,42.45 108.23,41.22 111.8,41.22 113.14,42.56 113.14,44.66 113.89,45.41 118.64,45.41 120.28,47.05 122.67,47.05 125.97,50.35 128.25,50.35 128.79,50.88 128.79,51.34 129.63,52.18 129.78,52.18 130.03,52.43 130.03,52.76 131.16,53.89 133.18,53.89 134.77,55.48 v4(135.48,55.48)
  IN2 w0.089: v9(71.46,34.24) 71.46,34.12 70.83,33.48 69.68,33.48 68.13,35.03 68.13,39.88 v9(69.05,40.8)
LPC_CLK_TPM: length 131.3
  TOP w0.127: R158.2 68.78,38.68 69.63,39.53 v9(69.94,39.53) ; R53.2 EC1.1 153.5,59.39 153.04,59.85 152.33,59.85 152.13,60.05 v7(152.13,61.12) 152.13,61.6 152.46,61.93 152.92,61.93 v9(153.22,62.23)
  IN1 w0.089: v9(133.59,55.18) 133.59,54.96 132.98,54.35 131.97,54.35 131.88,54.45 130.81,54.45 129.12,52.76 129.12,52.58 127.57,51.03 125.82,51.03 122.95,48.16 120.51,48.16 118.35,46 113.34,46 112.53,45.19 112.53,42.8 111.62,41.89 108.48,41.89 105.76,44.61 102.27,44.61 99.88,42.22 97.5,42.22 96.02,40.75 95.54,40.75 94.68,39.88 94.68,31.81 92.47,29.6 82.08,29.6 77.3,34.37 75.12,34.37 73.87,35.62 73.26,35.62 72.55,34.9 v9(71.46,34.9)
  IN2 w0.089: v9(69.94,39.53) 69.43,39.02 69.43,35.74 70.44,34.73 71.28,34.73 v9(71.46,34.9) ; v9(153.22,62.23) 152.26,63.2 152.26,64.22 150.77,65.71 148.12,65.71 148,65.59 146.36,65.59 145.9,65.13 139.2,65.13 138.81,65.52 135.68,65.52 135.44,65.28 134.25,65.28 132.9,63.94 132.9,59.95 132.75,59.8 132.75,56.02 v9(133.59,55.18)
LPC_LAD0: length 203.8
  TOP w0.127: v9(150.84,59.21) 149.54,59.21 149.44,59.11 R50.2 ; U4.K1 134.33,55.48 v9(134.33,55.48) ; R219.2 v6(188.94,21.16)
  IN1 w0.089: v6(70.67,36.45) 71.61,35.51 72.3,35.51 72.5,35.72 72.5,36.15 73.09,36.73 73.72,36.73 75.49,34.97 77.69,34.97 82.46,30.21 92.06,30.21 93.84,31.99 93.84,39.91 95.29,41.36 95.72,41.36 97.19,42.83 99.6,42.83 101.99,45.22 105.51,45.22 106.9,46.6 118.08,46.6 120.24,48.76 122.68,48.76 126.68,52.76 127.72,52.76 128.1,53.14 128.49,53.14 130.42,55.08 132.96,55.08 133.36,55.48 v9(134.33,55.48) ; v9(150.84,59.21) 150.84,60.51 151.27,60.95 153.83,60.95 154.88,59.9 154.88,55.88 160.32,50.44 165.15,50.44 167.55,48.04 170.01,48.04 172.04,46 172.04,30.43 173.8,28.68 173.8,20.78 175.88,18.7 176.59,18.7 177.28,19.38 179.26,19.38 180.02,18.62 182.46,18.62 182.86,18.22 184.29,18.22 184.99,18.91 184.99,19.75 186.04,20.81 186.62,20.81 186.98,21.16 v6(188.94,21.16)
  IN2 w0.089: v9(150.84,59.21) 150.84,59.24 150.86,59.21 153.12,59.21 153.98,60.08 153.98,60.58 151.66,62.91 151.66,63.98 150.52,65.12 149.57,65.12 149.29,65.4 146.44,65.4 145.94,64.9 139.05,64.9 138.66,65.3 136.22,65.3 135.82,64.9 134.55,64.9 133.17,63.52 133.17,56.63 v9(134.33,55.48)
  BOTTOM w0.089: 70.22,38.74 70.43,38.95 70.43,40.17 70.56,40.31 70.56,40.65 U16.AU14
  BOTTOM w0.127: v6(70.67,36.45) 70.22,36.91 70.22,38.74
