# Allegro board dad13cmbag0-g-roger-165XL.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_B_A12: length 113.4
  TOP w0.089: v9(75.6,12.32) 75.4,12.53 v7(74.84,12.53) 73.75,12.53
  IN1 w0.165: v5(49.49,40.77) 49.49,40.68 48.98,40.17 48.98,39.25 48.35,38.62 48.35,35.03 53.84,29.54 53.84,27.74 57.46,24.12 57.46,22.27 56.25,21.06 56.25,19.35 56.45,19.14 56.68,19.14 56.88,19.35 56.88,20.79 57.05,20.96 57.29,20.96 57.46,20.79 57.46,18.79 60.02,16.23 61.77,16.23 62.91,15.09 65.45,15.09 67.38,17.02 68.46,17.02 69.25,17.81 69.86,17.81 70.24,17.43 73.54,17.43 74.28,16.69 74.28,16.29 73.86,15.87 73.86,12.69 74.18,12.37 75.55,12.37 v9(75.6,12.32)
  IN2 w0.076: v5(66.43,12.73) 66.63,12.93 69.22,12.93 69.94,12.21 70.48,12.21 70.55,12.29 70.55,12.53 70.63,12.6 70.78,12.6 70.86,12.53 70.86,12.27 70.93,12.2 71.08,12.2 71.16,12.28 71.16,12.53 71.24,12.6 71.39,12.6 71.47,12.53 71.47,12.29 71.56,12.2 71.71,12.2 71.77,12.25 71.77,12.53 71.85,12.6 72,12.6 72.08,12.53 72.08,12.29 72.17,12.2 72.29,12.2 72.38,12.29 72.38,12.53 72.46,12.6 72.61,12.6 72.69,12.53 72.69,12.29 72.76,12.21 72.92,12.21 72.99,12.29 72.99,12.53 73.07,12.6 73.22,12.6 73.3,12.53 73.3,12.29 73.37,12.21 73.53,12.21 73.6,12.29 73.6,12.53 73.68,12.6 73.83,12.6 73.91,12.53 73.91,12.29 73.98,12.21 74.17,12.21 74.25,12.3 74.25,12.5 74.36,12.6 75.32,12.6 v9(75.6,12.32) 86.14,12.32 86.42,12.6 88.66,12.6 v5(88.78,12.73)
  IN4 w0.076: v2(59.83,13.37) 60.84,13.37 61.35,12.86 65.31,12.86 65.54,12.63 66.05,12.63 66.15,12.73 v5(66.43,12.73) 66.61,12.91 66.79,12.91 66.86,12.83 66.86,12.68 66.94,12.6 67.09,12.6 67.17,12.68 67.17,12.83 67.24,12.91 68.23,12.91 69.36,14.04 70.74,14.04 71.03,13.75 v2(71.36,13.75) ; v2(93.71,13.75) 93.38,13.75 93.09,14.04 91.72,14.04 90.59,12.91 89.6,12.91 89.52,12.83 89.52,12.68 89.44,12.6 89.29,12.6 89.21,12.68 89.21,12.83 89.14,12.91 88.96,12.91 v5(88.78,12.73) 88.5,12.73 88.4,12.63 87.89,12.63 87.67,12.86 83.91,12.86 83.39,13.37 v2(82.18,13.37)
  IN4 w0.165: v5(49.49,40.77) 49.24,41.02 v2(49.24,41.04)
  BOTTOM w0.102: v2(71.36,13.75) 71,13.39 U23.N7
  BOTTOM w0.127: v2(93.71,13.75) 93.71,13.73 U25.N7
M_B_A13: length 124
  TOP w0.089: v9(81.67,9.48) 81.67,8.84 v7(81.85,8.67) 81.85,8.61 R442.2
  IN1 w0.165: v9(81.67,9.48) 86,9.48 86.2,9.68 86.2,11.02 86,11.22 83.39,11.22 83.21,11.4 83.21,11.66 83.39,11.84 85.75,11.84 85.94,12.03 85.94,12.29 85.75,12.48 84.13,12.48 83.93,12.68 83.93,15.05 87.11,18.23 87.84,18.96 87.84,22.61 87.08,23.37 85.58,23.37 76.62,32.34 71.33,32.34 69.89,33.79 69.89,38.76 63.54,45.11 59.11,45.11 v5(58.6,44.61)
  IN2 w0.076: v5(68.51,9.58) 68.61,9.68 74.76,9.68 74.99,9.45 80.1,9.45 80.22,9.58 81.57,9.58 v9(81.67,9.48) 81.75,9.4 86.83,9.4 87.13,9.71 87.84,9.71 87.92,9.78 87.92,10.09 88.12,10.29 90.79,10.29 91.2,9.89 91.7,9.89 91.86,9.73 91.86,8.95 91.6,8.69 91.07,8.69 90.87,8.89 v5(90.87,9.58)
  IN4 w0.076: v2(96.56,10.97) 96.56,10.98 96.28,11.26 93,11.26 91.32,9.58 v5(90.87,9.58) 90.84,9.61 89.11,9.61 88.94,9.43 86.93,9.43 85.89,10.47 v2(85.81,10.47) ; v2(63.46,10.47) 63.54,10.47 64.58,9.43 66.58,9.43 66.76,9.61 68.49,9.61 v5(68.51,9.58) 68.97,9.58 70.65,11.26 73.92,11.26 74.2,10.98 v2(74.2,10.97)
  IN4 w0.165: v2(58.29,45.45) 58.6,45.14 v5(58.6,44.61)
  BOTTOM w0.076: U22.T3 63.03,10.9 v2(63.46,10.47) ; v2(85.81,10.47) 85.38,10.9 U24.T3
M_B_A14: length 121.1
  TOP w0.089: v9(78.85,8.31) 78.85,8.06 v7(79.31,7.6) 79.33,7.57 R435.2
  IN1 w0.165: v9(78.85,8.31) 79.26,7.9 80.05,7.9 80.17,7.78 80.17,7.19 80.3,7.07 80.63,7.07 80.76,7.19 80.76,7.78 80.88,7.9 81.24,7.9 81.37,7.78 81.37,7.19 81.49,7.07 81.89,7.07 82.02,7.19 82.02,7.98 81.54,8.46 79.56,8.46 78.98,9.05 78.98,10.59 78.45,11.12 78.45,11.48 77.76,12.17 77.76,13.14 77.23,13.67 77.23,14.69 76.64,15.27 76.64,16.73 76.8,16.89 76.8,18.31 75.83,19.28 75.56,19.28 74.11,20.73 71.72,20.73 71.06,21.39 63.28,21.39 63,21.67 63,25.87 62.87,26 62.57,26 62.44,25.87 62.44,25.23 62.32,25.1 61.99,25.1 61.86,25.23 61.86,27.02 59.62,29.25 59.62,30.94 59.33,31.23 56.45,31.23 52.41,35.28 52.41,38.83 52.09,39.15 52.09,39.71 51.44,40.36 51.2,40.36 50.98,40.58 50.98,41.04 50.45,41.56 v5(50.45,41.94)
  IN2 w0.076: v5(88.43,8.64) 88.43,9 88.4,9.02 88.27,9.02 87.92,8.67 87.59,8.67 87.46,8.54 87.11,8.54 87.06,8.49 87.06,8.36 87,8.31 86.85,8.31 86.78,8.39 86.78,8.49 86.7,8.56 86.55,8.56 86.47,8.49 86.47,8.39 86.4,8.31 86.24,8.31 86.17,8.39 86.17,8.49 86.09,8.56 85.94,8.56 85.86,8.49 85.86,8.39 85.79,8.31 85.63,8.31 85.56,8.39 85.56,8.49 85.48,8.56 85.33,8.56 85.25,8.49 85.25,8.39 85.18,8.31 85.02,8.31 84.95,8.39 84.95,8.49 84.87,8.56 84.72,8.56 84.64,8.49 84.64,8.39 84.57,8.31 84.41,8.31 84.34,8.39 84.34,8.49 84.26,8.56 84.11,8.56 84.03,8.49 84.03,8.39 83.96,8.31 83.8,8.31 83.73,8.39 83.73,8.49 83.65,8.56 83.5,8.56 83.42,8.49 83.42,8.39 83.35,8.31 v9(78.85,8.31) 77.6,8.31 77.36,8.31 77.12,8.06 71.53,8.06 71.41,8.18 67.02,8.18 66.56,8.64 v5(66.08,8.64)
  IN4 w0.076: v2(93.36,10.97) 93.15,10.97 93.05,10.88 93.05,10.09 91.45,8.49 90.95,8.49 90.87,8.56 90.87,8.67 90.8,8.74 90.64,8.74 90.57,8.67 90.57,8.56 90.49,8.49 90.34,8.49 90.26,8.56 90.26,8.67 90.19,8.74 90.04,8.74 89.96,8.67 89.96,8.56 89.88,8.49 88.78,8.49 88.63,8.64 v5(88.43,8.64) 86.8,8.64 84.76,10.69 83.61,10.69 83.33,10.97 v2(82.18,10.97) ; v2(71,10.97) 70.79,10.97 70.7,10.88 70.7,10.09 69.1,8.49 68.6,8.49 68.52,8.56 68.52,8.67 68.45,8.74 68.29,8.74 68.22,8.67 68.22,8.56 68.14,8.49 67.99,8.49 67.91,8.56 67.91,8.67 67.84,8.74 67.68,8.74 67.61,8.67 67.61,8.56 67.53,8.49 66.43,8.49 66.28,8.64 v5(66.08,8.64) 64.45,8.64 62.41,10.69 60.11,10.69 v2(59.83,10.97)
  IN4 w0.165: v2(50.21,42.2) 50.21,42.18 v5(50.45,41.94)
M_B_A15: length 121.5
  TOP w0.089: v9(78.11,12.6) 77.81,12.6 v7(77.38,13.03) 76.82,13.59 74.72,13.59 R452.2
  IN1 w0.165: v9(78.11,12.6) 78.11,13.3 77.58,13.83 77.58,14.97 77,15.55 77,16.63 77.09,16.72 77.09,18.81 76.21,19.69 75.66,19.69 75.02,20.33 75.02,20.91 74.74,21.19 71.86,21.19 71.1,21.95 64.67,21.95 64.54,22.07 64.54,23.82 64.41,23.94 64.07,23.94 63.94,23.82 63.94,22.07 63.81,21.95 63.51,21.95 63.37,22.09 63.37,26.03 59.99,29.4 59.99,31.48 59.87,31.6 58.53,31.6 58.4,31.73 58.4,32.08 58.53,32.21 59.59,32.21 59.71,32.34 59.71,32.66 59.57,32.8 56.47,32.8 56.35,32.92 56.35,33.25 56.47,33.38 58.63,33.38 58.75,33.5 58.75,33.81 58.62,33.94 54.62,33.94 52.85,35.71 52.85,38.89 52.44,39.3 52.44,39.8 51.85,40.39 51.85,40.96 51.01,41.8 51.01,43.36 50.81,43.57 49.11,43.57 48.98,43.44 48.98,42.7 49.11,42.57 v5(50.45,42.57)
  IN2 w0.076: v5(65.8,12.98) 66.02,13.21 69.4,13.21 69.68,12.93 77.35,12.93 77.68,12.6 v9(78.11,12.6) 80.78,12.6 80.86,12.68 80.86,12.73 80.94,12.81 81.09,12.81 81.16,12.73 81.16,12.68 81.24,12.6 81.39,12.6 81.47,12.68 81.47,12.73 81.54,12.81 81.7,12.81 81.77,12.73 81.77,12.68 81.85,12.6 82,12.6 82.08,12.68 82.08,12.73 82.15,12.81 82.31,12.81 82.38,12.73 82.38,12.68 82.46,12.6 82.61,12.6 82.69,12.68 82.69,12.73 82.76,12.81 82.92,12.81 82.99,12.73 82.99,12.68 83.07,12.6 83.22,12.6 83.3,12.68 83.3,12.73 83.37,12.81 83.53,12.81 83.6,12.73 83.6,12.68 83.68,12.6 83.83,12.6 83.91,12.68 83.91,12.73 83.98,12.81 84.14,12.81 84.21,12.73 84.21,12.68 84.29,12.6 84.44,12.6 84.52,12.68 84.52,12.73 84.59,12.81 84.75,12.81 84.82,12.73 84.82,12.68 84.9,12.6 85.05,12.6 85.13,12.68 85.13,12.73 85.2,12.81 85.35,12.81 85.43,12.73 85.43,12.68 85.51,12.6 85.73,12.6 85.81,12.68 85.81,12.91 85.89,12.98 v5(88.15,12.98)
  IN4 w0.076: v2(59.83,14.17) 60.2,13.8 60.79,13.8 61.5,13.09 65.47,13.09 65.57,12.98 v5(65.8,12.98) 65.8,13.11 65.83,13.15 68.09,13.15 69.2,14.25 70.92,14.25 v2(71,14.17) ; v2(82.18,14.17) 83.18,14.17 84.26,13.09 87.82,13.09 87.92,12.98 v5(88.15,12.98) 88.15,13.11 88.18,13.15 90.44,13.15 91.55,14.25 93.27,14.25 v2(93.36,14.17)
  IN4 w0.165: v5(50.45,42.57) 50.21,42.82 v2(50.21,42.85)
M_B_BS0: length 125
  TOP w0.089: v9(80.99,13.97) 80.99,13.59 v7(81.95,12.63) 82.05,12.53 R444.2
  IN1 w0.165: v5(57.59,44.49) 57.59,44.64 57.44,44.78 57.19,44.78 56.91,44.51 56.91,44.25 57.16,44 57.16,43.77 57.54,43.39 57.72,43.39 58.53,42.57 59.7,42.57 59.84,42.43 60.03,42.43 60.03,42.43 60.22,42.43 60.36,42.3 60.36,42.11 60.36,41.92 60.49,41.78 60.68,41.78 60.68,41.78 60.87,41.78 61,41.65 61,41.46 61,41.46 61,41.27 61.14,41.14 61.33,41.14 61.52,41.14 61.65,41 61.65,40.81 61.65,40.81 61.65,40.62 61.78,40.49 61.97,40.49 61.97,40.49 62.16,40.49 62.3,40.36 62.3,40.17 62.3,39.98 62.43,39.84 62.62,39.84 62.62,39.84 62.81,39.84 62.95,39.71 62.95,39.52 62.94,39.52 62.94,39.33 63.08,39.2 63.27,39.2 63.46,39.2 63.59,39.06 63.59,38.87 63.59,38.87 63.59,38.68 63.72,38.55 63.91,38.55 63.92,38.55 64.1,38.55 64.24,38.42 64.24,38.23 64.24,38.04 64.37,37.9 64.56,37.9 64.56,37.9 64.75,37.9 64.89,37.77 64.89,37.58 64.88,37.58 64.88,37.39 65.02,37.26 65.21,37.26 65.4,37.26 65.53,37.12 65.53,36.46 66.01,35.98 66.01,33.46 70.27,29.2 74.5,29.2 76.25,27.45 76.25,27.26 75.88,26.89 75.88,26.71 76.1,26.49 76.28,26.49 76.66,26.87 76.84,26.87 77.06,26.64 77.06,26.46 76.69,26.09 76.69,25.91 76.94,25.65 77.12,25.65 78.02,26.56 78.2,26.56 78.42,26.35 78.42,26.17 77.51,25.26 77.51,25.08 81.63,20.97 81.63,18.43 80.81,17.61 80.81,15.5 81.9,14.41 81.9,13.57 82.64,12.83 82.64,10.8 82.79,10.65 85.51,10.65 85.63,10.52 85.63,10.18 85.51,10.05 82.2,10.05 82.08,10.18 82.08,12.49 81.66,12.91 81.11,12.91 80.99,13.03 v9(80.99,13.97)
  IN2 w0.076: v5(68.21,15.14) 68.69,15.14 69.1,14.74 79.18,14.74 79.94,13.97 v9(80.99,13.97) 81.14,14.13 81.96,14.13 82.03,14.2 82.03,14.28 82.11,14.36 82.26,14.36 82.34,14.28 82.34,14.2 82.41,14.13 82.57,14.13 82.64,14.2 82.64,14.28 82.72,14.36 82.87,14.36 82.95,14.28 82.95,14.2 83.02,14.13 83.18,14.13 83.25,14.2 83.25,14.28 83.33,14.36 83.48,14.36 83.56,14.28 83.56,14.2 83.63,14.13 83.78,14.13 83.86,14.2 83.86,14.28 83.93,14.36 84.11,14.36 84.16,14.3 84.16,14.2 84.24,14.13 84.95,14.13 85.05,14.23 85.05,14.51 85.07,14.53 88.4,14.53 88.87,15 88.87,15.56 88.96,15.65 89.15,15.65 89.23,15.57 89.23,15.22 89.3,15.14 89.48,15.14 89.56,15.22 89.56,15.6 89.61,15.65 89.83,15.65 89.89,15.6 89.89,15.22 89.96,15.14 v5(90.56,15.14)
  IN4 w0.076: v2(97.36,14.17) 97.04,14.48 95.87,14.48 95.23,15.12 90.59,15.12 v5(90.56,15.14) 90.33,15.14 90.26,15.07 90.26,14.74 90.15,14.63 89.95,14.63 89.88,14.71 89.88,15.14 89.8,15.22 89.57,15.22 89.51,15.16 89.51,14.7 89.42,14.61 89.21,14.61 89.16,14.66 89.16,15.02 89.09,15.09 88.83,15.09 88.76,15.02 88.76,14.71 88.66,14.61 87.82,14.61 87.38,14.17 v2(86.18,14.17) ; v2(63.83,14.17) 65.03,14.17 65.47,14.61 66.3,14.61 66.41,14.71 66.41,15.02 66.48,15.09 66.74,15.09 66.81,15.02 66.81,14.66 66.86,14.61 67.07,14.61 67.15,14.7 67.15,15.16 67.22,15.22 67.45,15.22 67.52,15.14 67.52,14.71 67.6,14.63 67.8,14.63 67.9,14.74 67.9,15.07 67.98,15.14 v5(68.21,15.14) 68.23,15.12 72.88,15.12 73.52,14.48 74.69,14.48 v2(75,14.17)
  IN4 w0.165: v2(57.29,44.8) 57.29,44.79 v5(57.59,44.49)
M_B_BS1: length 126.3
  TOP w0.089: v9(80.17,11.97) 80.43,11.71 v7(81.04,11.71) 81.8,10.95 82.55,10.95 R438.2
  IN1 w0.165: v5(56.75,43.83) 56.75,43.75 58.3,42.19 59.34,42.19 59.7,41.84 59.7,41.41 59.93,41.18 60.41,41.18 60.61,40.97 60.61,40.49 60.77,40.34 61.4,40.34 61.53,40.21 61.53,40.02 61.29,39.78 61.29,39.61 61.43,39.48 61.64,39.48 61.86,39.69 62.05,39.69 62.18,39.56 62.18,39.37 61.89,39.08 61.89,38.91 62.02,38.78 62.21,38.78 62.48,39.05 62.67,39.05 62.8,38.91 62.8,38.72 62.53,38.46 62.53,38.27 62.67,38.13 62.88,38.13 63.15,38.4 63.34,38.4 63.47,38.27 63.47,38.05 63.18,37.76 63.18,37.6 63.32,37.46 63.53,37.46 63.8,37.73 63.99,37.73 64.12,37.6 64.12,37.35 63.75,36.99 63.75,36.85 63.92,36.68 64.12,36.68 64.55,37.11 64.73,37.11 64.91,36.94 64.91,36.68 64.65,36.43 64.65,35.73 64.78,35.6 65.52,35.6 65.64,35.48 65.64,33.43 65.22,33.01 65.22,32.83 65.46,32.59 65.64,32.59 65.91,32.86 66.09,32.86 66.32,32.63 66.32,32.45 65.99,32.13 65.99,31.95 66.22,31.72 66.4,31.72 66.72,32.05 66.9,32.05 67.16,31.8 67.16,31.62 66.83,31.29 66.83,31.11 67.05,30.9 67.23,30.9 67.36,31.03 67.54,31.03 67.76,30.8 67.76,30.62 67.63,30.49 67.63,30.31 67.83,30.11 68.01,30.11 68.34,30.43 68.52,30.43 68.73,30.22 68.73,30.04 68.39,29.7 68.39,29.55 68.62,29.32 68.8,29.32 69.12,29.65 69.3,29.65 69.52,29.43 69.52,29.25 69.21,28.95 69.21,28.77 69.44,28.55 69.62,28.55 69.91,28.83 73.35,28.83 73.48,28.71 73.48,28.19 73.6,28.06 73.87,28.06 74,28.19 74,28.58 74.21,28.79 74.39,28.79 74.84,28.33 74.84,28.15 74.52,27.83 74.52,27.65 74.77,27.4 74.95,27.4 75.28,27.72 75.46,27.72 75.73,27.45 75.73,27.27 75.45,26.98 75.45,26.62 80.84,21.23 80.9,21.23 81.2,20.93 81.2,18.38 80.5,17.68 80.5,12.55 80.6,12.45 81.59,12.45 81.71,12.34 81.71,10.85 81.58,10.72 81.16,10.72 81.04,10.85 v7(81.04,11.71) 80.88,11.87 80.27,11.87 v9(80.17,11.97)
  IN2 w0.076: v5(65.62,12.22) 67.04,12.22 67.27,12.45 69.22,12.45 69.76,11.92 74.56,11.92 74.64,11.99 80.15,11.99 v9(80.17,11.97) 80.29,11.97 80.37,11.89 80.37,11.7 80.44,11.63 80.59,11.63 80.67,11.7 80.67,11.97 80.75,12.04 80.9,12.04 80.97,11.97 80.97,11.7 81.05,11.63 81.2,11.63 81.28,11.7 81.28,11.97 81.36,12.04 81.51,12.04 81.58,11.97 81.58,11.7 81.66,11.63 81.81,11.63 81.89,11.7 81.89,11.97 81.97,12.04 82.12,12.04 82.19,11.97 82.19,11.7 82.27,11.63 82.42,11.63 82.5,11.7 82.5,11.97 82.57,12.04 82.73,12.04 82.8,11.97 82.8,11.7 82.88,11.63 83.03,11.63 83.11,11.7 83.11,11.97 83.18,12.04 83.34,12.04 83.41,11.97 83.41,11.7 83.49,11.63 83.67,11.63 83.74,11.7 83.74,11.97 83.82,12.04 83.97,12.04 84.05,11.97 84.05,11.7 84.12,11.63 84.28,11.63 84.35,11.7 84.35,11.97 84.43,12.04 84.58,12.04 84.66,11.97 84.66,11.7 84.73,11.63 84.92,11.63 85.02,11.73 85.02,12.01 85.1,12.08 85.3,12.08 85.35,12.03 85.35,11.73 85.46,11.63 85.6,11.63 85.68,11.71 85.68,11.97 85.76,12.04 85.96,12.04 86.07,11.94 86.07,11.69 86.14,11.62 86.37,11.62 86.45,11.69 86.45,12.12 86.55,12.22 v5(87.97,12.22)
  IN4 w0.076: v2(92.92,13.77) 91.81,13.77 90.41,12.37 90.15,12.37 90.08,12.45 90.08,12.65 90,12.73 89.85,12.73 89.77,12.65 89.77,12.45 89.7,12.37 88.12,12.37 v5(87.97,12.22) 87.92,12.22 87.53,12.62 83.56,12.62 83.09,13.09 81.67,13.09 v2(81.38,13.37) ; v2(59.03,13.37) 59.31,13.09 60.74,13.09 61.21,12.62 65.17,12.62 65.57,12.22 v5(65.62,12.22) 65.77,12.37 67.35,12.37 67.42,12.45 67.42,12.65 67.5,12.73 67.65,12.73 67.73,12.65 67.73,12.45 67.8,12.37 68.06,12.37 69.45,13.77 v2(70.57,13.77)
  IN4 w0.165: v2(56.43,44.15) 56.43,44.14 v5(56.75,43.83)
  BOTTOM w0.127: U25.N8 92.92,13.74 v2(92.92,13.77) ; U23.N8 70.57,13.74 v2(70.57,13.77)
M_B_BS2: length 127.6
  TOP w0.089: R453.2 72.09,15.07 73.96,15.07 74.92,14.1 v7(75.4,14.1) v9(75.98,14.1)
  IN1 w0.165: v9(75.98,14.1) 75.73,14.1 75.63,14.2 75.63,14.99 75.96,15.32 75.96,16.23 75.63,16.56 75.63,18.21 74.09,19.75 71.25,19.75 70.86,20.13 61.17,20.13 60.92,20.39 60.92,23.27 60.72,23.47 59.84,23.47 59.64,23.68 59.64,24.03 59.84,24.24 60.75,24.24 60.92,24.41 60.92,24.65 60.75,24.82 60.23,24.82 60.03,25.02 60.03,25.56 60.87,26.4 60.87,26.67 60.68,26.86 60.41,26.86 59.88,26.34 59.7,26.34 59.5,26.55 59.5,26.73 60.05,27.27 60.05,27.5 59.89,27.66 59.66,27.66 59.11,27.11 58.93,27.11 58.68,27.36 58.68,27.54 59.26,28.11 59.26,28.29 58.93,28.62 58.75,28.62 58.18,28.05 58,28.05 57.78,28.27 57.78,28.45 58.03,28.7 58.03,28.88 57.78,29.13 57.6,29.13 57.34,28.86 57.14,28.86 56.21,29.79 56.21,30.07 51.24,35.03 51.24,38.94 50.9,39.29 50.9,39.55 49.92,40.53 49.92,40.9 48.82,42 48.61,42 48.35,41.74 48.35,41.51 48.93,40.92 v5(48.93,40.7)
  IN2 w0.076: v5(67.32,14.36) 67.32,14.13 67.27,14.08 64.86,14.08 64.78,14.15 64.78,14.57 64.93,14.72 66.56,14.72 66.6,14.76 68.64,14.76 69.2,14.2 69.45,14.2 69.53,14.28 69.53,14.36 69.61,14.43 69.76,14.43 69.83,14.36 69.83,14.28 69.91,14.2 70.06,14.2 70.14,14.28 70.14,14.36 70.21,14.43 70.37,14.43 70.44,14.36 70.44,14.28 70.52,14.2 70.67,14.2 70.75,14.28 70.75,14.36 70.82,14.43 70.98,14.43 71.05,14.36 71.05,14.28 71.13,14.2 71.28,14.2 71.36,14.28 71.36,14.36 71.43,14.43 71.59,14.43 71.66,14.36 71.66,14.28 71.94,14 72.43,14 72.58,14.15 72.58,14.36 72.65,14.43 72.81,14.43 72.88,14.36 72.88,14.28 72.96,14.2 73.11,14.2 73.19,14.28 73.19,14.36 73.26,14.43 73.42,14.43 73.49,14.36 73.49,14.28 73.57,14.2 73.74,14.2 73.81,14.28 73.81,14.36 73.89,14.43 74.04,14.43 74.12,14.36 74.12,14.28 74.19,14.2 74.35,14.2 74.42,14.28 74.42,14.36 74.5,14.43 74.65,14.43 74.73,14.36 74.73,14.28 74.8,14.2 74.96,14.2 75.03,14.28 75.03,14.36 75.11,14.43 75.26,14.43 75.34,14.36 75.34,14.28 75.41,14.2 75.88,14.2 v9(75.98,14.1) 76.16,13.92 76.26,13.92 76.33,14 76.33,14.38 76.41,14.46 76.56,14.46 76.64,14.38 76.64,14 76.71,13.92 76.87,13.92 76.94,14 76.94,14.38 77.02,14.46 77.17,14.46 77.25,14.38 77.25,14 77.32,13.92 77.48,13.92 77.55,14 77.55,14.38 77.63,14.46 77.78,14.46 77.86,14.38 77.86,14 77.93,13.92 78.19,13.92 78.27,13.85 78.27,13.77 78.34,13.7 85.13,13.7 85.63,14.2 88.81,14.2 88.92,14.32 88.92,14.65 89.09,14.81 89.57,14.81 89.67,14.71 v5(89.67,14.36)
  IN4 w0.076: v2(74.2,14.17) 73.4,14.17 72.65,14.91 68.49,14.91 67.93,14.36 v5(67.32,14.36) 65.54,14.36 65.08,13.9 63.61,13.9 63.54,13.97 63.54,14.15 63.48,14.2 63.36,14.2 63.31,14.15 63.31,13.77 63.21,13.67 62.21,13.67 62.16,13.72 62.16,13.85 62.6,14.28 62.92,14.28 v2(63.03,14.17) ; v2(96.56,14.17) 95.75,14.17 95.01,14.91 90.84,14.91 90.28,14.36 v5(89.67,14.36) 87.89,14.36 87.44,13.9 85.96,13.9 85.89,13.97 85.89,14.15 85.84,14.2 85.71,14.2 85.66,14.15 85.66,13.77 85.56,13.67 84.57,13.67 84.52,13.72 84.52,13.85 84.95,14.28 85.27,14.28 v2(85.38,14.17)
  IN4 w0.165: v5(48.93,40.7) 48.59,41.03 v2(48.59,41.04)
M_B_CAS#: length 125.6
  TOP w0.089: v9(81.9,17.28) 82.53,16.65 82.53,16.56 R455.2
  IN1 w0.165: v5(58.6,43.85) 58.91,43.85 59.3,43.45 63.32,43.45 68.34,38.43 68.34,33.13 70.75,30.71 76.14,30.71 76.33,30.52 76.33,30.35 75.86,29.88 75.86,29.7 76.06,29.5 76.24,29.5 76.71,29.97 76.89,29.97 77.11,29.74 77.11,29.56 76.64,29.09 76.64,28.91 76.84,28.71 77.07,28.71 77.48,29.11 77.74,29.11 81.22,25.64 81.22,25.38 80.23,24.39 80.23,24.21 80.44,24 80.65,24 81.66,25.01 81.84,25.01 82.07,24.79 82.07,24.61 81.04,23.58 81.04,23.4 81.29,23.15 81.47,23.15 82.5,24.17 82.68,24.17 82.92,23.93 82.92,23.75 81.82,22.65 81.82,22.5 82.07,22.25 82.25,22.25 83.34,23.34 83.52,23.34 83.75,23.1 83.75,22.92 82.76,21.93 82.76,21.75 83.19,21.32 83.75,21.32 83.88,21.44 83.88,22.23 84.01,22.36 84.36,22.36 84.49,22.23 84.49,21.47 84.62,21.35 85.4,21.35 85.53,21.22 85.53,20.88 85.4,20.76 84.62,20.76 84.49,20.63 84.49,20.3 84.62,20.17 85.4,20.17 85.53,20.05 85.53,19.74 85.4,19.61 84.62,19.61 84.49,19.49 84.49,19.13 84.62,19 85.38,19 85.51,18.88 85.51,18.55 85.38,18.42 84.62,18.42 84.49,18.29 84.49,17.76 84.26,17.53 82.15,17.53 v9(81.9,17.28)
  IN2 w0.076: v5(90.51,17.51) 90.38,17.38 90.18,17.38 90.05,17.51 90.05,18 89.96,18.09 89.82,18.09 89.72,18 89.72,17.45 89.65,17.38 89.44,17.38 89.37,17.45 89.37,17.62 89.26,17.73 89.1,17.73 88.99,17.62 88.99,17.48 88.86,17.35 87.08,17.35 87.03,17.4 86.45,17.4 86.39,17.35 86.39,17.1 86.31,17.02 86.16,17.02 86.09,17.1 86.09,17.35 86.01,17.43 85.86,17.43 85.78,17.35 85.78,17.1 85.7,17.02 85.55,17.02 85.48,17.1 85.48,17.35 85.4,17.43 85.25,17.43 85.17,17.35 85.17,17.1 85.1,17.02 84.94,17.02 84.87,17.1 84.87,17.35 84.79,17.43 84.64,17.43 84.56,17.35 84.56,17.1 84.49,17.02 84.33,17.02 84.26,17.1 84.26,17.35 84.18,17.43 84.03,17.43 83.95,17.35 83.95,17.1 83.88,17.02 83.72,17.02 83.65,17.1 83.65,17.35 83.57,17.43 83.42,17.43 83.34,17.35 83.34,17.1 83.27,17.02 83.11,17.02 83.04,17.1 83.04,17.35 82.96,17.43 82.81,17.43 82.73,17.35 82.73,17.1 82.66,17.02 82.5,17.02 82.43,17.1 82.43,17.28 82.35,17.35 81.98,17.35 v9(81.9,17.28) 81.7,17.07 81.14,17.07 80.96,17.25 80.76,17.25 80.69,17.17 80.69,17.05 80.61,16.97 80.46,16.97 80.38,17.05 80.38,17.15 80.31,17.23 80.15,17.23 80.08,17.15 80.08,17.05 80,16.97 79.85,16.97 79.67,17.15 77.48,17.15 77,17.63 68.29,17.63 v5(68.16,17.51)
  IN4 w0.076: v2(96.56,15.77) 95.96,16.36 93.13,16.36 91.81,17.68 90.69,17.68 v5(90.51,17.51) 90.46,17.56 88.76,17.56 88.54,17.34 86.43,17.34 86.34,17.25 85.76,17.25 85.63,17.12 85.63,16.97 86.01,16.59 86.01,16.46 85.38,15.83 v2(85.38,15.77) ; v2(74.2,15.77) 73.59,16.39 70.75,16.39 69.45,17.68 68.34,17.68 v5(68.16,17.51) 68.11,17.56 66.41,17.56 66.19,17.34 64.08,17.34 63.99,17.25 63.41,17.25 63.28,17.12 63.28,16.97 63.66,16.59 63.66,16.46 63.03,15.83 v2(63.03,15.77)
  IN4 w0.165: v2(58.29,44.15) 58.58,43.85 v5(58.6,43.85)
M_B_CKE0: length 105.3
  TOP w0.089: R457.2 69.99,15.25 70.38,15.25 v7(70.95,15.83) 71.02,15.9 73.33,15.9 73.92,16.49 v9(73.92,16.51)
  IN1 w0.165: v9(73.92,16.51) 73.92,16.67 73.44,17.15 73.06,17.15 72.82,16.91 70.15,16.91 69.51,16.27 67.8,16.27 66.08,14.55 62.95,14.55 61.62,15.87 59.87,15.87 57.97,17.77 57.31,17.77 54.87,20.22 54.87,25.94 53.48,27.33 53.48,29.39 47.86,35.02 47.86,40.15 48.04,40.34 48.31,40.34 48.5,40.15 48.5,39.55 v5(48.55,39.5)
  IN2 w0.076: v5(86.73,16.21) 86.5,16.44 74,16.44 v9(73.92,16.51) 73.9,16.54 73.06,16.54 72.83,16.77 69.33,16.77 69.05,17.05 68.74,17.05 68.54,16.84 68.39,16.84 68.31,16.77 68.31,16.57 68.23,16.49 68.12,16.49 68.05,16.57 68.05,16.64 67.97,16.72 67.82,16.72 67.74,16.64 67.74,16.57 67.67,16.49 67.51,16.49 67.44,16.57 67.44,16.64 67.36,16.72 67.21,16.72 67.13,16.64 67.13,16.2 67.04,16.11 66.92,16.11 66.83,16.2 66.83,16.64 66.75,16.72 66.6,16.72 66.52,16.64 66.52,15.84 66.43,15.75 64.5,15.75 64.37,15.88 v5(64.37,16.21)
  IN4 w0.076: v2(91.12,17.1) 90.92,16.9 88.99,16.9 88.88,16.79 88.55,16.79 88.05,16.29 86.8,16.29 v5(86.73,16.21) 86.6,16.21 85.63,15.24 84.12,15.24 83.58,15.77 v2(80.58,15.77) ; 61.2,15.76 61.72,15.24 63.25,15.24 64.22,16.21 v5(64.37,16.21) 64.45,16.29 65.69,16.29 66.2,16.79 66.53,16.79 66.63,16.9 68.56,16.9 v2(68.77,17.1)
  IN4 w0.102: 61.2,15.76 61.19,15.77 v2(58.23,15.77)
  IN4 w0.165: v2(48.54,39.09) 48.54,39.49 v5(48.55,39.5)
  BOTTOM w0.076: v2(68.77,17.1) 68.72,17.05 68.72,16.13 69.08,15.77 U23.K9 ; v2(91.12,17.1) 91.07,17.05 91.07,16.13 91.43,15.77 U25.K9
M_B_CKE1: length 109.4
  TOP w0.089: R458.2 68.86,15.27 69.13,15.27 v7(69.68,15.83) 70.19,16.34 72.83,16.34 v9(73.31,16.82)
  IN1 w0.165: v9(73.31,16.82) 72.93,16.44 72.22,16.44 69.19,13.41 66.98,13.41 66.21,14.18 62.8,14.18 62.18,14.8 60.42,14.8 57.82,17.41 57.16,17.41 54.51,20.06 54.51,25.67 52.99,27.18 52.99,29.36 47.48,34.87 47.48,41.3 v5(47.81,41.64)
  IN2 w0.076: v5(86.73,16.84) 86.73,16.79 86.65,16.72 79.72,16.72 79.61,16.82 v9(73.31,16.82) 73.14,16.82 72.87,17.09 69.52,17.09 69.28,17.33 68.49,17.33 68.23,17.07 68.08,17.07 68.01,17 67.68,17 67.6,17.07 67.6,17.54 67.51,17.63 67.38,17.63 67.29,17.54 67.29,17.07 67.22,17 67.07,17 66.99,17.07 66.99,17.53 66.91,17.61 66.76,17.61 66.68,17.53 66.68,17.07 66.61,17 66.46,17 66.38,17.07 66.38,17.5 66.28,17.61 66.13,17.61 66.02,17.5 66.02,16.57 65.9,16.44 64.73,16.44 v5(64.37,16.79)
  IN4 w0.076: 61.41,15.97 61.88,15.5 63.15,15.5 64.37,16.72 v5(64.37,16.79) 64.63,16.54 65.54,16.54 66.08,17.07 66.38,17.07 66.63,17.33 67.78,17.33 67.95,17.15 68.36,17.15 68.62,17.4 68.89,17.4 69.05,17.25 69.05,17.12 69.12,17.05 69.22,17.05 69.3,17.12 69.3,17.25 69.35,17.3 69.45,17.3 69.63,17.12 69.63,16.9 69.56,16.82 v2(69.4,16.82) ; v2(80.58,16.57) 81.07,16.08 83.75,16.08 84.34,15.5 85.51,15.5 86.56,16.55 86.56,16.68 v5(86.73,16.84) 87.03,16.54 87.89,16.54 88.43,17.07 88.73,17.07 88.99,17.33 90.13,17.33 90.31,17.15 90.71,17.15 90.97,17.4 91.25,17.4 91.4,17.25 91.4,17.12 91.48,17.05 91.58,17.05 91.65,17.12 91.65,17.25 91.7,17.3 91.81,17.3 91.98,17.12 91.98,16.9 91.91,16.82 v2(91.75,16.82)
  IN4 w0.089: v5(47.81,41.64) 47.81,41.51 47.61,41.31 v2(47.61,41.04)
  IN4 w0.102: 61.41,15.97 61.13,16.25 58.55,16.25 v2(58.23,16.57)
  BOTTOM w0.076: v2(91.75,16.82) 91.76,16.82 U25.J9 ; v2(69.4,16.82) 69.4,16.82 U23.J9
M_B_CLKN0: length 129.6
  TOP w0.076: R234.1 79.01,18.28 79.21,18.47 79.31,18.47 v9(79.52,18.26)
  IN1 w0.089: v5(55.68,43.85) 55.68,43.67 55.76,43.59 55.98,43.59 56.57,43 56.57,41.72 57.34,40.95 57.43,40.95 57.45,40.93
  IN1 w0.203: 57.45,40.93 57.69,40.68 57.69,40.41 58.58,39.52 58.58,38.46 58.83,38.21 59.2,38.21 59.55,38.56 60.16,38.56 60.82,37.9 60.82,37.37 60.25,36.81 60.25,36.52 60.63,36.15 60.91,36.15 61.42,36.66 62.01,36.66 62.45,36.21 62.45,34.94 63.48,33.91 63.48,33.3 63.94,32.85 63.94,32.49 69,27.44 69,25.86 69.2,25.66 69.66,25.66 69.86,25.86 69.86,27.36 70.32,27.82 71.03,27.82 71.36,27.49 71.36,25.94 71.76,25.53 72.48,25.53 72.86,25.91 74.71,25.91 80.39,20.24 80.39,18.68 79.99,18.29 79.54,18.29 v9(79.52,18.26)
  IN2 w0.102: v5(88.12,17.98) 88.12,18.11 88,18.24 87.79,18.24 87.55,18.48 87.55,18.75 87.45,18.85 87.24,18.85 87.14,18.75 87.14,18.28 86.94,18.08 86.52,18.08 86.3,18.3 86.3,19.4 86.2,19.5 85.89,19.5 85.79,19.4 85.79,18.32 85.57,18.1 85.1,18.1 84.88,18.32 84.88,19.42 84.78,19.52 84.47,19.52 84.37,19.42 84.37,18.32 84.15,18.1 83.68,18.1 83.45,18.32 83.45,19.42 83.35,19.52 83.05,19.52 82.95,19.42 82.95,18.32 82.73,18.1 82.26,18.1 82.03,18.32 82.03,19.42 81.93,19.52 81.63,19.52 81.52,19.42 81.52,18.38 81.26,18.11 80.67,18.11 80.19,18.6 79.85,18.6 v9(79.52,18.26) 79.2,18.58 78.93,18.58 78.51,19 78.28,19 78.21,18.93 78.21,18.68 77.98,18.46 77.51,18.46 77.29,18.68 77.29,18.95 77.19,19.05 76.88,19.05 76.78,18.95 76.78,18.68 76.56,18.46 76.09,18.46 75.87,18.68 75.87,18.95 75.77,19.05 75.46,19.05 75.36,18.95 75.36,18.68 75.14,18.46 74.67,18.46 74.45,18.68 74.45,18.93 74.34,19.03 74.04,19.03 73.94,18.93 73.94,18.68 73.72,18.46 73.24,18.46 73.02,18.68 73.02,18.93 72.92,19.03 72.62,19.03 72.52,18.93 72.52,18.68 72.3,18.46 71.82,18.46 71.6,18.68 71.6,18.93 71.5,19.03 71.19,19.03 71.09,18.93 71.09,18.68 70.87,18.46 70.4,18.46 70.18,18.68 70.18,18.93 70.08,19.03 69.77,19.03 69.67,18.93 69.67,18.68 69.45,18.46 68.98,18.46 68.76,18.68 68.76,18.93 68.65,19.03 68.35,19.03 68.25,18.93 68.25,18.76 67.95,18.46 66.84,18.46 66.62,18.24 66.04,18.24 v5(65.77,17.98)
  IN4 w0.089: v5(55.68,43.85) 55.38,44.15 v2(55.38,44.15)
  IN4 w0.102: v2(72.07,16.95) 72.07,17.25 71.93,17.39 71.44,17.39 70.41,18.42 69.22,18.42 69,18.64 69,18.72 68.9,18.83 68.59,18.83 68.49,18.73 68.49,18.64 68.27,18.42 67.8,18.42 67.58,18.64 67.58,18.72 67.45,18.85 67.19,18.85 66.6,18.26 66.06,18.26 v5(65.77,17.98) 65.28,18.47 63.52,18.47 63.3,18.69 63.3,19.09 63.2,19.19 62.08,19.19 61.98,19.09 61.98,18.72 61.68,18.41 61.68,18.2 61.77,18.11 61.84,18.11 62.06,17.89 62.06,17.57 61.87,17.38 61.02,17.38 60.9,17.26 v2(60.9,16.95) ; v2(94.43,16.95) 94.43,17.2 94.26,17.37 93.82,17.37 93.23,17.95 93.23,18.16 92.97,18.42 91.91,18.42 91.5,18.83 91.04,18.83 90.63,18.42 90.15,18.42 89.74,18.84 89.24,18.84 88.64,18.24 88.38,18.24 v5(88.12,17.98) 87.63,18.47 85.9,18.47 85.68,18.69 85.68,19.09 85.5,19.27 85.14,19.27 84.97,19.09 84.97,18.82 84.64,18.5 84.12,18.5 84.03,18.41 84.03,18.2 84.12,18.11 84.19,18.11 84.41,17.89 84.41,17.57 84.19,17.35 83.35,17.35 83.25,17.26 v2(83.25,16.95)
  BOTTOM w0.102: v2(60.9,16.95) 60.9,17.12 60.81,17.2 60.68,17.2 60.53,17.05 60.53,16.47 60.14,16.08 60.04,16.08 59.83,15.87 U22.K7 ; v2(83.25,16.95) 83.25,17.12 83.16,17.2 83.03,17.2 82.88,17.05 82.88,16.47 82.49,16.08 82.39,16.08 82.18,15.87 U24.K7 ; U25.K7 93.67,16.08 93.81,16.08 94.04,16.31 94.04,17.02 94.18,17.16 94.36,17.16 94.43,17.09 v2(94.43,16.95) ; U23.K7 71.34,16.11 71.38,16.11 71.71,16.44 71.71,17.09 71.8,17.17 71.94,17.17 72.07,17.04 v2(72.07,16.95)
M_B_CLKP0: length 128.8
  TOP w0.076: v9(79.52,19.1) 79.52,18.87 79.27,18.62 79.21,18.62 79.01,18.82 R233.1
  IN1 w0.089: v5(55.68,43.11) 55.68,43.36 55.74,43.41 55.9,43.41 56.39,42.92 56.39,41.64 57.21,40.83 57.21,40.74 57.23,40.72
  IN1 w0.203: v9(79.52,19.1) 79.43,19.1 79.31,18.98 79.31,18.75 79.46,18.6 79.87,18.6 80.08,18.81 80.08,20.11 74.58,25.61 72.98,25.61 72.6,25.23 71.64,25.23 71.05,25.81 71.05,27.36 70.9,27.51 70.44,27.51 70.16,27.23 70.16,25.74 69.78,25.35 69.07,25.35 68.69,25.74 68.69,27.31 63.64,32.36 63.64,32.72 63.18,33.18 63.18,33.79 62.15,34.82 62.15,36.09 61.88,36.35 61.54,36.35 61.04,35.85 60.5,35.85 59.95,36.4 59.95,36.94 60.51,37.5 60.51,37.77 60.03,38.26 59.68,38.26 59.33,37.91 58.7,37.91 58.28,38.33 58.28,39.39 57.39,40.28 57.39,40.56 57.23,40.72
  IN2 w0.102: v5(65.77,18.7) 66.02,18.44 66.53,18.44 66.75,18.67 67.87,18.67 68.05,18.84 68.05,19.01 68.27,19.23 68.74,19.23 68.96,19.01 68.96,18.77 69.06,18.67 69.37,18.67 69.47,18.77 69.47,19.01 69.69,19.23 70.16,19.23 70.38,19.01 70.38,18.77 70.48,18.67 70.79,18.67 70.89,18.77 70.89,19.01 71.11,19.23 71.58,19.23 71.8,19.01 71.8,18.77 71.91,18.67 72.21,18.67 72.31,18.77 72.31,19.01 72.53,19.23 73.01,19.23 73.23,19.01 73.23,18.77 73.33,18.67 73.63,18.67 73.73,18.77 73.73,19.01 73.96,19.23 74.43,19.23 74.65,19.01 74.65,18.77 74.75,18.67 75.06,18.67 75.16,18.77 75.16,19.04 75.38,19.26 75.85,19.26 76.07,19.04 76.07,18.77 76.17,18.67 76.48,18.67 76.58,18.77 76.58,19.04 76.8,19.26 77.27,19.26 77.49,19.04 77.49,18.77 77.6,18.67 77.9,18.67 78,18.77 78,19.01 78.2,19.21 78.59,19.21 79.01,18.79 79.2,18.79 v9(79.52,19.1) 79.81,18.8 80.27,18.8 80.76,18.32 81.17,18.32 81.32,18.47 81.32,19.51 81.54,19.73 82.02,19.73 82.24,19.51 82.24,18.41 82.34,18.31 82.64,18.31 82.74,18.4 82.74,19.51 82.96,19.73 83.44,19.73 83.66,19.51 83.66,18.41 83.76,18.31 84.07,18.31 84.17,18.4 84.17,19.51 84.39,19.73 84.86,19.73 85.08,19.51 85.08,18.41 85.18,18.31 85.49,18.31 85.59,18.4 85.59,19.48 85.81,19.7 86.28,19.7 86.5,19.48 86.5,18.38 86.61,18.28 86.85,18.28 86.93,18.36 86.93,18.83 87.16,19.05 87.54,19.05 87.75,18.84 87.75,18.56 87.87,18.44 88.05,18.44 88.12,18.52 v5(88.12,18.7)
  IN4 w0.089: v5(55.68,43.11) 55.38,43.41 v2(55.38,43.5)
  IN4 w0.102: v2(94.43,17.75) 94.24,17.57 93.9,17.57 93.43,18.04 93.43,18.25 93.05,18.62 92,18.62 91.58,19.04 90.96,19.04 90.54,18.62 90.24,18.62 89.82,19.04 89.16,19.04 88.56,18.44 88.38,18.44 v5(88.12,18.7) 88.12,18.6 88.06,18.53 87.86,18.53 87.72,18.67 85.98,18.67 85.88,18.78 85.88,19.17 85.58,19.47 85.06,19.47 84.76,19.17 84.76,18.9 84.56,18.7 84.03,18.7 83.83,18.5 83.83,18.11 84.03,17.91 84.11,17.91 84.21,17.81 84.21,17.66 84.11,17.56 83.45,17.56 v2(83.25,17.75) ; v2(60.9,17.75) 61.07,17.58 61.78,17.58 61.86,17.66 61.86,17.81 61.76,17.91 61.68,17.91 61.47,18.12 61.47,18.5 61.78,18.8 61.78,19.17 62,19.39 63.28,19.39 63.5,19.17 63.5,18.78 63.6,18.67 65.36,18.67 65.53,18.51 65.7,18.51 65.77,18.57 v5(65.77,18.7) 66,18.46 66.52,18.46 67.11,19.05 67.54,19.05 67.78,18.81 67.78,18.72 67.89,18.62 68.19,18.62 68.29,18.72 68.29,18.81 68.51,19.03 68.98,19.03 69.21,18.81 69.21,18.72 69.31,18.62 70.49,18.62 71.52,17.59 71.91,17.59 v2(72.07,17.75)
  BOTTOM w0.102: U25.J7 93.36,16.53 93.6,16.29 93.73,16.29 93.84,16.4 93.84,17.1 94.43,17.69 v2(94.43,17.75) ; U22.J7 59.83,16.39 59.93,16.29 60.05,16.29 60.32,16.55 60.32,17.14 60.89,17.71 60.89,17.75 v2(60.9,17.75) ; U23.J7 71,16.41 71.1,16.31 71.3,16.31 71.51,16.52 71.51,17.17 72.07,17.73 v2(72.07,17.75) ; U24.J7 82.18,16.39 82.28,16.29 82.41,16.29 82.67,16.55 82.67,17.14 83.25,17.71 83.25,17.75 v2(83.25,17.75)
M_B_CS#0: length 113.5
  TOP w0.089: R235.2 79.33,14.43 80.1,14.43 v7(81.04,15.37) 81.47,15.8 v9(81.67,15.8)
  IN1 w0.165: v5(59.49,43.85) 59.7,43.85 59.98,44.12 60.31,44.12 60.59,43.85 63.51,43.85 68.94,38.42 68.94,33.33 70.88,31.4 76.26,31.4 85.68,21.98 86.99,21.98 87.12,21.85 87.12,21.54 86.99,21.42 86.23,21.42 86.1,21.29 86.1,20.96 86.23,20.83 86.99,20.83 87.12,20.71 87.12,20.38 86.99,20.25 86.32,20.25 86.19,20.12 86.19,19.82 86.32,19.69 86.99,19.69 87.12,19.56 87.12,19.26 86.99,19.14 86.2,19.14 86.08,19.01 86.08,18.31 84.43,16.67 81.85,16.67 81.65,16.46 81.65,15.83 v9(81.67,15.8)
  IN2 w0.076: v5(91.22,16.67) 91.04,16.67 90.99,16.62 90.99,16.34 90.94,16.29 90.76,16.29 90.69,16.36 90.69,16.72 90.62,16.78 90.48,16.78 90.42,16.73 90.42,16.32 90.36,16.26 90.15,16.26 90.08,16.34 90.08,16.67 90,16.74 89.85,16.74 89.77,16.67 89.77,16.31 89.7,16.24 89.54,16.24 89.47,16.31 89.47,16.67 89.39,16.74 89.24,16.74 89.16,16.67 89.16,16.31 89.09,16.24 88.94,16.24 88.86,16.31 88.86,16.67 88.78,16.74 88.63,16.74 88.55,16.67 88.55,16.21 88.17,15.83 87.72,15.83 87.55,15.66 86.33,15.66 86.12,15.88 81.75,15.88 v9(81.67,15.8) 81.65,15.78 78.09,15.78 77.99,15.68 69.86,15.68 v5(68.87,16.67)
  IN4 w0.076: v2(97.36,14.97) 97.36,15.59 97.27,15.68 96.99,15.68 96.82,15.51 96.27,15.51 95.59,16.18 93,16.18 92.67,16.51 91.68,16.51 91.53,16.67 v5(91.22,16.67) 91.17,16.62 89.14,16.62 89.09,16.57 88.73,16.57 88.66,16.49 88.66,16.29 88.4,16.03 87.28,16.03 87,15.75 86.88,15.75 86.78,15.85 86.65,15.85 86.55,15.75 86.55,15.65 86.7,15.5 86.7,15.42 86.6,15.32 86.07,15.32 85.89,15.14 85.89,15.04 85.96,14.97 v2(86.18,14.97) ; v2(63.83,14.97) 63.6,14.97 63.54,15.04 63.54,15.14 63.71,15.32 64.25,15.32 64.35,15.42 64.35,15.5 64.2,15.65 64.2,15.75 64.3,15.85 64.42,15.85 64.53,15.75 64.65,15.75 64.93,16.03 66.05,16.03 66.3,16.29 66.3,16.49 66.38,16.57 66.74,16.57 66.79,16.62 68.82,16.62 v5(68.87,16.67) 69.17,16.67 69.33,16.51 70.32,16.51 70.65,16.18 73.24,16.18 73.92,15.51 74.46,15.51 74.64,15.68 74.91,15.68 75,15.59 v2(75,14.97)
  IN4 w0.165: v2(59.19,44.15) 59.19,44.15 v5(59.49,43.85)
M_B_CS#1: length 112.6
  TOP w0.089: R230.2 84.3,15.45 82.69,15.45 v9(81.98,16.16)
  IN1 w0.165: v5(59.62,44.48) 63.51,44.48 69.4,38.59 69.4,33.42 70.96,31.86 76.51,31.86 85.99,22.38 87.28,22.38 87.49,22.18 87.49,19.11 84.63,16.25 83.42,16.25 83.22,16.05 83.22,14.15 83.02,13.95 82.74,13.95 82.53,14.15 82.53,15.96 82.33,16.16 v9(81.98,16.16)
  IN2 w0.076: v5(92.64,16.03) 92.44,16.03 92.29,16.18 92.29,16.58 92.2,16.67 92.07,16.67 91.98,16.58 91.98,16.13 91.88,16.03 91.75,16.03 91.63,16.16 91.63,16.87 91.45,17.05 88.3,17.05 88.17,16.92 88.17,16.16 88.1,16.08 87.84,16.08 87.74,16.18 87.74,16.4 87.68,16.46 87.42,16.46 87.36,16.4 87.36,16.16 87.28,16.08 87.13,16.08 86.92,15.87 86.48,15.87 86.19,16.16 v9(81.98,16.16) 77.68,16.16 77.56,16.03 73.53,16.03 73.45,16.11 73.45,16.26 73.38,16.34 73.23,16.34 73.15,16.26 73.15,16.11 73.07,16.03 72.92,16.03 72.84,16.11 72.84,16.26 72.77,16.34 72.62,16.34 72.54,16.26 72.54,16.11 72.46,16.03 72.31,16.03 72.23,16.11 72.23,16.26 72.16,16.34 72.01,16.34 71.93,16.26 71.93,16.11 71.85,16.03 71.7,16.03 71.63,16.11 71.63,16.26 71.55,16.34 71.4,16.34 71.32,16.26 71.32,16.11 71.24,16.03 71.09,16.03 71.02,16.11 71.02,16.26 70.94,16.34 70.79,16.34 70.71,16.26 70.71,16.11 70.63,16.03 v5(70.29,16.03)
  IN4 w0.076: v2(75.8,14.97) 75.8,14.89 75.57,14.66 74.91,14.66 74.34,15.24 73.7,15.24 73.01,15.93 70.39,15.93 v5(70.29,16.03) 70.09,16.24 66.94,16.24 66.48,15.78 65.14,15.78 64.63,15.27 v2(64.63,14.97) ; v2(86.98,14.97) 86.98,15.27 87.49,15.78 88.83,15.78 89.29,16.24 92.44,16.24 v5(92.64,16.03) 92.75,15.93 95.36,15.93 96.05,15.24 96.69,15.24 97.27,14.66 97.93,14.66 98.15,14.89 v2(98.15,14.97)
  IN4 w0.165: v5(59.62,44.48) 59.62,45.01 v2(59.19,45.45)
M_B_DQ0: length 29.9
  IN3 w0.152: v2(59.24,39.09) 59.17,39.01 59.17,38.56 57.79,37.19 57.79,36.92 58.11,36.61 58.11,31.74 57.69,31.32 57.69,31.02 58.08,30.63 58.08,29.88 57.69,29.49 57.69,29.27 57.88,29.07 58.41,29.07 58.54,28.95 58.54,28.03 58.1,27.59 58.1,26.5 57.9,26.29 57.51,26.29 57.31,26.09 57.31,25.64 57.59,25.35 57.59,23.19 57.24,22.84 57.24,22.3 57.59,21.94 57.59,20.47 58.33,19.73 59.75,19.73 60.12,19.37 60.73,19.37 60.86,19.24 60.86,18.72 60.73,18.59 59.77,18.59 59.6,18.42 59.6,18.18 59.77,18.01 60.28,18.01 60.46,17.84 60.46,17.3 60.33,17.17 60.02,17.17 v2(59.83,17.37)
M_B_DQ1: length 30.2
  IN3 w0.152: v2(59.83,18.97) 59.83,19.12 59.6,19.35 58.17,19.35 57.79,19.73 56.91,19.73 56.78,19.86 56.78,20.15 57.21,20.58 57.21,21.78 56.86,22.14 56.86,23 57.21,23.35 57.21,25.1 56.88,25.43 56.88,26.37 57.69,27.18 57.69,28 57.82,28.12 58,28.12 58.13,28.25 58.13,28.58 58.02,28.68 57.44,28.68 57.29,28.83 57.29,29.63 57.69,30.03 57.69,30.46 57.29,30.87 57.29,31.48 57.73,31.91 57.73,32.74 57.34,33.13 57.34,33.58 57.73,33.97 57.73,34.39 57.34,34.78 57.34,35.33 57.73,35.72 57.73,36.45 57.34,36.84 57.34,37.14 56.64,37.85 56.64,38.03 56.88,38.28 57.06,38.28 57.54,37.8 57.82,37.8 58.76,38.74 58.76,39.4 58.51,39.65 58.51,39.86 58.73,40.09 58.89,40.09 v2(59.24,39.74)
M_B_DQ2: length 29.2
  IN3 w0.152: v2(60.59,39.09) 60.54,39.03 60.54,36.78 60.46,36.71 60.46,35.18 60.08,34.8 60.08,33.68 60.46,33.3 60.46,32.49 60.08,32.1 60.08,31.04 61.3,29.82 61.3,26.61 61.81,26.1 61.81,24.57 61.94,24.44 62.27,24.44 62.37,24.54 62.37,25.01 62.49,25.13 62.77,25.13 62.9,25.01 62.9,23.02 63.03,22.89 63.31,22.89 63.43,23.02 63.43,23.47 63.56,23.6 63.85,23.6 63.98,23.47 63.98,22.99 64.1,22.86 64.53,22.86 64.65,22.74 64.65,22.43 64.53,22.31 63.69,22.31 63.56,22.18 63.56,21.87 63.69,21.75 64.5,21.75 64.61,21.63 64.61,21.18 64.5,21.06 63.94,21.06 63.84,20.96 63.84,20.27 64.22,19.89 64.22,19.13 64.06,18.97 v2(63.83,18.97)
M_B_DQ3: length 30.8
  IN3 w0.152: v2(60.59,39.74) 60.88,39.44 60.88,36.62 60.84,36.58 60.84,34.93 60.54,34.62 60.54,33.77 60.84,33.46 60.84,32.33 60.46,31.95 60.46,31.2 61.68,29.98 61.68,26.76 65.31,23.13 65.31,22.23 65,21.91 65,21 65.77,20.22 65.77,19.23 65.64,19.11 65.31,19.11 65.19,19.23 65.19,20.1 65.06,20.22 64.76,20.22 64.63,20.1 64.63,17.3 64.51,17.17 64.25,17.17 64.12,17.3 64.12,17.66 63.99,17.79 63.45,17.79 v2(63.03,17.37)
M_B_DQ4: length 31
  IN3 w0.152: v2(59.24,40.39) 59.01,40.62 58.72,40.62 58,39.9 58,39.63 58.2,39.43 58.2,38.74 57.92,38.46 57.54,38.46 57.26,38.74 56.81,38.74 56.25,38.18 56.25,37.7 56.96,36.99 56.96,36.68 57.34,36.29 57.34,35.88 56.96,35.49 56.96,32.85 57.34,32.47 57.34,32.12 56.73,31.5 56.25,31.5 56.12,31.37 56.12,30.89 56.91,30.1 56.91,29.87 56.12,29.09 56.12,28.73 57.24,27.61 57.24,27.39 56.94,27.09 56.36,27.09 56.12,26.85 56.12,26.55 56.4,26.27 56.4,25.35 56.83,24.92 56.83,23.51 56.4,23.08 56.4,22.06 56.78,21.68 56.78,20.71 56.4,20.32 56.4,19.66 56.71,19.35 57.63,19.35 58.01,18.97 v2(59.03,18.97)
M_B_DQ5: length 31.4
  IN3 w0.152: v2(59.03,17.37) 57.43,18.97 56.55,18.97 56.02,19.51 56.02,20.5 56.4,20.88 56.4,21.52 56.02,21.9 56.02,23.24 56.45,23.67 56.45,24.36 56.02,24.79 56.02,25.96 55.74,26.24 55.74,34.09 55.89,34.24 56.27,34.24 56.58,34.55 56.58,36.71 56.45,36.83 55.89,36.83 55.76,36.96 55.76,38.23 57.74,40.21 57.74,41.23 57.87,41.36 58.71,41.36 59.18,41.82 59.36,41.82 59.6,41.58 59.6,41.4 v2(59.24,41.04)
M_B_DQ6: length 29.8
  IN3 w0.089: 60.23,39.65 60.23,39.76 60.48,40.01 v2(60.48,40.39)
  IN3 w0.152: 60.23,39.65 60.28,39.6 60.28,37.16 60.08,36.96 60.08,35.44 59.7,35.06 59.7,33.46 60.03,33.13 60.03,32.59 59.68,32.24 59.68,30.9 60.84,29.74 60.84,26.52 61.43,25.94 61.43,24.74 60.82,24.13 60.82,23.7 60.97,23.55 61.86,23.55 61.99,23.42 61.99,22.86 61.63,22.51 61.63,21.21 61.98,20.87 62.25,20.87 62.4,21.02 62.4,22.23 62.53,22.36 63.05,22.36 63.18,22.23 63.18,20.7 63.41,20.47 63.41,18.91 63.23,18.73 63.23,18.3 63.36,18.17 v2(63.83,18.17)
M_B_DQ7: length 32.1
  IN3 w0.089: 59.98,39.6 59.98,39.76 60.18,39.96 60.18,40.82 60.05,40.95 60.05,41.1 60.16,41.21 60.31,41.21 v2(60.48,41.04)
  IN3 w0.152: 59.98,39.6 59.98,37.77 59.7,37.49 59.7,35.56 59.32,35.18 59.32,33.3 59.62,33 59.62,32.73 59.3,32.4 59.3,30.35 60,29.65 60.33,29.65 60.46,29.52 60.46,29.24 60.33,29.11 59.86,29.11 59.73,28.99 59.73,28.71 59.86,28.58 60.33,28.58 60.46,28.45 60.46,28.17 60.33,28.05 59.86,28.05 59.73,27.92 59.73,27.64 59.86,27.51 60.33,27.51 60.46,27.39 60.46,27.11 60.33,26.98 59.86,26.98 59.73,26.85 59.73,24.9 59.89,24.74 60.11,24.74 60.27,24.9 60.27,25.63 60.42,25.79 60.64,25.79 60.8,25.63 60.8,24.65 60.44,24.29 60.44,22.13 60.74,21.82 60.99,21.82 61.17,21.64 61.17,21.39 60.99,21.21 60.56,21.21 60.44,21.09 60.44,20.74 60.6,20.58 61.64,20.58 61.95,20.27 62.53,20.27 v2(63.03,19.77)
M_B_DQ8: length 30.8
  IN4 w0.152: v2(59.83,20.57) 59.82,20.57 59.52,20.87 59.52,22.31 59.8,22.59 60.08,22.59 60.21,22.71 60.21,23.45 60.09,23.57 58.38,23.57 58.13,23.82 58.13,25.51 58.36,25.74 59.31,25.74 59.44,25.87 59.44,26.19 59.31,26.32 58.86,26.32 58.73,26.45 58.73,26.95 58.86,27.08 59.31,27.08 59.43,27.21 59.43,27.49 59.31,27.61 58.86,27.61 58.73,27.74 58.73,28 58.86,28.12 59.31,28.12 59.43,28.25 59.43,28.53 59.31,28.66 58.79,28.66 58.67,28.78 58.67,29.06 58.79,29.19 59.31,29.19 59.43,29.32 59.43,29.66 59.01,30.08 59.01,30.92 58.71,31.22 58.71,31.65 59.01,31.96 59.01,32.41 58.71,32.72 58.71,33 59.01,33.3 59.01,33.56 58.89,33.68 58.4,33.68 58.28,33.81 58.28,34.09 58.4,34.22 58.89,34.22 59.02,34.35 59.02,34.63 58.89,34.76 58.08,34.76 57.95,34.89 57.95,36.58 58.15,36.78 58.38,36.78 58.71,37.12 58.71,37.34 58.92,37.55 59.47,37.55 59.8,37.88 59.8,38.1 60.06,38.36 60.94,38.36 v2(61.67,39.09)
M_B_DQ9: length 31.6
  IN4 w0.152: v2(59.83,22.97) 59.55,22.97 59.22,22.64 58.84,22.64 58.46,23.02 58.18,23.02 57.97,22.81 57.97,22.41 58.3,22.08 58.3,21.7 57.97,21.37 57.97,20.43 58.58,19.82 58.58,19.54 57.99,18.95 57.72,18.95 57.49,19.18 57.49,19.46 57.72,19.69 57.72,19.87 57.44,20.15 57.44,23.35 57.75,23.66 57.75,24.75 57.44,25.06 57.44,25.4 58.29,26.25 58.29,33.11 57.57,33.83 57.57,36.74 59.24,38.41 59.57,38.41 59.88,38.71 60.67,38.71 61.3,39.34 61.3,39.58 61.45,39.73 61.66,39.73 v2(61.67,39.74)
M_B_DQ10: length 31.7
  IN4 w0.152: v2(63.83,22.97) 63.83,21.91 63.41,21.49 63.41,21.06 63.59,20.88 63.59,20.05 63.79,19.84 67.12,19.84 67.24,19.97 67.24,22.25 66.76,22.74 66.08,22.74 65.94,22.88 65.94,23.17 66.04,23.27 66.48,23.27 66.61,23.4 66.61,23.7 66.48,23.83 66.04,23.83 65.91,23.96 65.91,24.49 65.26,25.14 65.26,26.29 64.93,26.62 64.7,26.62 64.37,26.29 64.11,26.29 63.94,26.46 63.94,26.64 64.32,27.02 64.32,27.23 63.52,28.03 63.52,29.54 61.66,31.41 61.66,36.07 63.02,37.44 v2(63.02,39.09)
M_B_DQ11: length 31.9
  IN4 w0.089: 62.75,38.97 62.75,39.46 v2(63.02,39.74)
  IN4 w0.152: v2(63.83,21.37) 63.99,21.21 63.99,20.35 64.12,20.22 64.42,20.22 64.75,20.55 65.08,20.55 65.41,20.22 66.74,20.22 66.86,20.35 66.86,20.65 66.74,20.78 65.58,20.78 65.45,20.91 65.45,21.21 65.58,21.34 66.74,21.34 66.86,21.47 66.86,21.75 66.74,21.87 66,21.87 65.53,22.34 65.53,24.33 64.88,24.98 64.88,25.63 64.61,25.91 63.95,25.91 63.41,26.45 63.41,26.65 63.8,27.04 63.8,27.22 63.6,27.42 63.42,27.42 63,27 62.82,27 62.61,27.21 62.61,27.39 63.14,27.91 63.14,29.38 61.27,31.25 61.27,36.22 62.75,37.7 62.75,38.97
M_B_DQ12: length 32
  IN4 w0.152: v2(59.03,22.17) 59.03,21.91 58.65,21.53 58.65,20.41 59.12,19.94 59.12,19.54 58.65,19.07 58.65,18.74 58.4,18.5 57.64,18.5 57.06,19.08 57.06,23.51 57.37,23.82 57.37,24.59 57.06,24.9 57.06,25.56 57.91,26.41 57.91,32.95 57.17,33.68 56.62,33.68 56.47,33.84 56.47,34.14 56.59,34.27 57.03,34.27 57.16,34.4 57.16,36.91 58.99,38.74 59.37,38.74 59.68,39.05 60.03,39.05 60.4,39.43 60.72,39.43 60.92,39.63 60.92,39.78 61.52,40.39 v2(61.78,40.39)
M_B_DQ13: length 33.5
  IN4 w0.152: v2(61.78,41.04) 61.62,41.04 60.64,40.06 60.41,40.06 59.78,39.43 58.56,39.43 58.38,39.25 58.38,38.69 56.78,37.09 56.78,34.78 56.65,34.65 56.25,34.65 56.09,34.49 56.09,33.41 56.27,33.23 57.09,33.23 57.52,32.8 57.52,26.56 56.63,25.67 56.63,24.79 56.99,24.43 56.99,23.97 56.63,23.61 56.63,18.97 57.48,18.11 58.6,18.11 59.5,19.01 59.5,20.17 59.22,20.45 59.22,20.49 59.03,20.68 v2(59.03,21.37)
M_B_DQ14: length 32.7
  IN4 w0.089: v2(63.02,40.39) 63.02,40.1 62.52,39.6 62.52,38.64 62.47,38.59 62.47,38.1
  IN4 w0.152: v2(63.03,22.97) 63.43,23.37 64.3,23.37 64.45,23.22 64.45,21.44 64.65,21.24 64.95,21.24 65.15,21.44 65.15,24.17 64.66,24.67 64.14,24.67 64,24.81 64,25.32 63.46,25.86 63.18,25.86 62.9,25.58 62.72,25.58 62.51,25.78 62.51,25.96 62.84,26.28 62.84,26.49 62.67,26.65 62.44,26.65 62.13,26.34 61.95,26.34 61.75,26.54 61.75,26.72 62.09,27.06 62.09,27.24 61.91,27.41 61.12,27.41 61.01,27.53 61.01,27.82 61.14,27.94 62.63,27.94 62.76,28.07 62.76,28.35 62.63,28.48 62.16,28.48 62.04,28.6 62.04,28.88 62.16,29.01 62.52,29.01 62.64,29.14 62.64,29.34 61.59,30.39 61.06,30.39 60.64,30.81 60.64,36.17 62.47,38 62.47,38.1
M_B_DQ15: length 33.7
  IN4 w0.089: v2(62.77,40.71) 62.75,40.68 62.75,40.09 62.32,39.65 62.32,38.74 62.16,38.59 62.16,38.16
  IN4 w0.152: 62.16,38.16 61.02,37.01 60.61,37.01 59.92,36.32 59.92,35.56 60.26,35.22 60.26,30.65 60.9,30.01 61.4,30.01 61.53,29.88 61.53,29.6 61.4,29.47 60.75,29.47 60.63,29.34 60.63,29.04 60.75,28.91 61.4,28.91 61.53,28.78 61.53,28.5 61.4,28.38 60.75,28.38 60.63,28.25 60.63,27.11 60.73,27 61.22,27 61.37,26.85 61.37,26.38 62.24,25.51 62.24,25.35 61.92,25.04 61.92,24.86 62.23,24.55 62.41,24.55 63.23,25.37 63.41,25.37 63.62,25.16 63.62,24.98 63.36,24.72 63.36,24.41 63.48,24.29 64.5,24.29 64.62,24.16 64.62,23.88 64.5,23.75 63.26,23.75 62.95,24.06 62.75,24.06 62.57,23.88 62.57,23.13 62.34,22.91 62.34,22.69 62.49,22.53 63.28,22.53 63.43,22.39 63.43,22.13 63.28,21.98 62.7,21.98 62.57,21.85 62.57,21.5 62.7,21.37 v2(63.03,21.37)
  BOTTOM w0.216: v2(62.77,40.71) 63.02,40.96 U16.AU25
M_B_DQ16: length 34.1
  IN3 w0.089: 60.79,41.1 60.03,41.86 60.03,43.52 v2(60.65,44.15)
  IN3 w0.152: 60.79,41.1 60.79,40.01 61.15,39.65 61.15,35.67 61.48,35.34 61.48,34.92 61.05,34.49 61.05,33.9 61.48,33.47 61.48,32.32 61.08,31.92 61.08,31.23 61.47,30.84 61.93,30.84 62.21,30.56 62.21,26.88 65.77,23.32 65.77,22.53 66.57,21.73 66.57,21.51 66.13,21.07 66.13,20.86 66.34,20.64 66.56,20.64 67,21.08 67.22,21.08 67.43,20.87 67.43,20.65 66.99,20.21 66.99,19.99 67.21,19.78 67.42,19.78 67.86,20.22 68.08,20.22 69.12,19.18 69.99,19.18 v2(70.2,18.97)
M_B_DQ17: length 34.9
  IN3 w0.089: 61.05,41 61.05,41.15 60.21,41.99 60.21,43.44 60.61,43.84 60.74,43.84 61,44.1 61,45.16 v2(60.7,45.45)
  IN3 w0.152: 61.05,41 61.05,40.16 61.48,39.73 61.48,35.99 61.86,35.61 61.86,34.76 61.46,34.36 61.46,34.03 61.86,33.63 61.86,32.16 61.46,31.76 61.46,31.39 61.58,31.27 62.11,31.27 62.6,30.79 62.6,27.54 66.8,23.34 66.8,23.13 66.36,22.69 66.36,22.48 66.58,22.26 66.79,22.26 67.23,22.69 67.44,22.69 67.66,22.48 67.66,22.26 67.23,21.83 67.23,21.64 69.3,19.56 70.41,19.56 v2(71,18.97)
M_B_DQ18: length 33.1
  IN3 w0.152: v2(75,18.97) 75,20.41 68.44,26.98 68.44,27.67 67,29.11 67,29.3 67.34,29.64 67.34,29.8 67.07,30.07 66.91,30.07 66.57,29.73 66.38,29.73 66.14,29.97 66.14,30.16 66.48,30.5 66.48,30.72 65.82,31.37 65.82,32.47 64.65,33.63 64.65,34.97 64.98,35.3 64.98,36.02 63.48,37.52 63.48,42.12 63.03,42.57 63.03,43.38 v2(61.61,44.8)
M_B_DQ19: length 35.1
  IN3 w0.152: v2(75,18.17) 75.45,18.62 75.45,20.6 71.46,24.59 71.46,25.61 71.33,25.73 70.44,25.73 70.19,25.99 70.19,26.88 69.94,27.13 69.05,27.13 68.89,27.28 68.89,28.8 68.56,29.14 68.03,29.14 67.78,29.39 67.78,29.92 67.37,30.33 67.37,30.89 67.03,31.23 66.55,31.23 66.2,31.58 66.2,32.62 65.03,33.79 65.03,34.82 65.39,35.17 65.39,36.05 63.76,37.67 63.76,43.29 v2(61.61,45.45)
M_B_DQ20: length 31.5
  IN3 w0.089: v2(60.65,42.2) 60.65,42.16 62.21,40.59 62.21,38.82 62.04,38.64 62.04,38.59 62.01,38.56
  IN3 w0.152: v2(71,17.37) 71.16,17.37 71.87,18.08 71.87,19.43 70.34,20.96 70.12,20.96 69.7,20.54 69.49,20.54 69.27,20.76 69.27,20.97 69.69,21.39 69.69,21.6 63.36,27.94 63.36,31.13 62.7,31.79 62.7,35.84 62.01,36.53 62.01,38.56
M_B_DQ21: length 32.9
  IN3 w0.089: v2(60.65,43.5) 60.39,43.23 60.39,42.09 61.36,41.11
  IN3 w0.152: v2(70.2,17.37) 70.58,17.75 70.8,17.75 71.46,18.41 71.46,19.29 70.48,20.27 70.14,20.27 69.81,19.94 69.46,19.94 68.69,20.71 68.69,20.93 69.15,21.39 69.15,21.61 62.98,27.78 62.98,30.97 62.29,31.65 62.29,35.72 61.76,36.25 61.76,40.09 61.4,40.44 61.4,41.08 61.36,41.11
M_B_DQ22: length 30.7
  IN3 w0.089: v2(61.61,42.2) 61.61,42.02 62.9,40.72 62.9,38.56
  IN3 w0.152: 62.9,38.56 62.9,37.11 63.89,36.12 63.89,33.32 64.96,32.25 64.96,29.93 64.61,29.58 64.61,29.4 64.85,29.16 65.03,29.16 65.36,29.49 65.54,29.49 65.75,29.28 65.75,29.1 65.43,28.77 65.43,28.59 65.62,28.4 66.6,28.4 66.89,28.12 66.89,26.21 67.32,25.77 67.82,25.77 68.13,25.46 68.13,24.96 68.4,24.69 68.89,24.69 69.28,24.31 69.28,23.82 69.67,23.42 70.16,23.42 73.03,20.55 73.42,20.55 v2(74.2,19.77)
M_B_DQ23: length 31.6
  IN3 w0.089: 63.15,38.61 63.15,38.69 63.13,38.71 63.13,40.95 63,41.08 62.9,41.08 62.04,41.94 62.04,42.75 61.94,42.85 v2(61.61,42.85)
  IN3 w0.152: v2(74.2,17.37) 74.61,17.78 74.61,20.02 71.18,23.45 71.18,23.7 67.6,27.28 67.6,27.97 65.41,30.15 65.41,32.33 64.27,33.48 64.27,35.13 64.6,35.46 64.6,35.95 63.15,37.39 63.15,38.61
M_B_DQ24: length 32.3
  IN4 w0.089: v2(62.56,43.5) 62.29,43.23 62.29,42.09 63.03,41.36 63.38,41.36 63.89,40.85 63.89,38.41
  IN4 w0.152: 63.89,38.41 63.89,36.63 62.93,35.67 62.93,35.31 63.59,34.65 63.59,34.37 62.93,33.71 62.93,33.46 63.64,32.74 63.64,31.14 65.77,29.02 65.77,28.25 65.95,28.07 66.72,28.07 66.97,27.82 67.44,27.82 67.65,27.61 67.65,27.46 67.27,27.08 67.27,26.85 67.44,26.67 67.62,26.67 68.01,27.06 68.19,27.06 68.4,26.85 68.4,26.67 68.01,26.27 68.01,26.11 69.63,24.48 69.63,24.13 69.26,23.77 69.26,23.59 69.49,23.36 69.67,23.36 70.12,23.81 70.3,23.81 70.52,23.6 70.52,23.42 70.11,23.02 70.11,22.81 70.55,22.38 70.55,21.03 v2(71,20.57)
M_B_DQ25: length 31
  IN4 w0.089: v2(62.56,42.2) 62.56,42.44 62.62,42.5 62.77,42.5 62.85,42.42 62.85,41.91 63.22,41.53 63.89,41.53 64.09,41.33 64.09,38.87 64.14,38.82
  IN4 w0.152: 64.14,38.82 64.22,38.74 64.22,36.5 63.64,35.92 63.64,35.34 64.04,34.93 64.04,34.19 63.64,33.78 63.64,33.28 64.02,32.9 64.02,31.3 64.26,31.07 64.73,31.07 65.03,30.76 65.03,30.33 65.29,30.08 65.72,30.08 65.93,29.86 65.93,29.39 66.23,29.1 66.7,29.1 66.89,28.91 66.89,28.44 67.13,28.2 67.6,28.2 68.92,26.87 68.92,26.65 68.57,26.3 68.57,26.08 68.82,25.83 69.04,25.83 69.39,26.19 69.61,26.19 69.86,25.94 69.86,25.72 69.5,25.37 69.5,25.15 69.76,24.9 69.97,24.9 70.33,25.25 70.54,25.25 70.79,25 70.79,24.79 70.44,24.43 70.44,24.22 70.69,23.96 70.91,23.96 71.26,24.32 71.48,24.32 71.75,24.05 71.75,22.79 71.54,22.59 71.21,22.59 71,22.79 v2(71,22.97)
M_B_DQ26: length 30.1
  IN4 w0.089: v2(63.51,42.2) 64.12,42.2 65.34,40.97 65.34,40.29 65.44,40.19 65.44,39.12 65.36,39.04
  IN4 w0.152: 65.36,39.04 65.24,38.92 65.24,32.25 72.96,24.52 72.96,22.89 73.54,22.3 73.54,20.75 72.81,20.02 72.81,19.84 73.08,19.56 73.26,19.56 74.2,20.5 v2(74.2,21.37)
M_B_DQ27: length 31.6
  IN4 w0.089: v2(63.51,42.8) 63.85,42.45 64.11,42.45 65.51,41.06 65.73,41.06 65.9,40.88 65.9,39.93 66.02,39.81 66.02,38.97 65.97,38.92
  IN4 w0.152: v2(75,21.37) 76.14,20.23 76.14,20.05 75.66,19.58 75.48,19.58 74.58,20.48 74.58,21.77 74.46,21.9 74.11,21.9 73.99,22.03 73.99,22.65 73.34,23.3 73.34,24.68 65.62,32.4 65.62,38.56 65.97,38.92
M_B_DQ28: length 33.3
  IN4 w0.089: v2(62.56,45.45) 61.94,44.83 61.94,41.91 62.85,41 62.93,41 63.04,40.89
  IN4 w0.152: 63.04,40.89 63.31,40.61 63.31,37.17 62.11,35.97 62.11,31.6 64.55,29.16 64.55,27.67 65.01,27.21 65.59,27.21 66.08,26.72 66.08,26.5 65.72,26.14 65.72,25.96 65.93,25.75 66.11,25.75 66.49,26.12 66.67,26.12 66.87,25.92 66.87,25.74 66.44,25.32 66.44,24.58 67.22,23.8 67.22,23.27 67.35,23.14 67.98,23.14 68.11,23.02 68.11,22.13 67.85,21.87 67.85,21.24 68.31,20.78 69.61,20.78 v2(70.2,21.37)
